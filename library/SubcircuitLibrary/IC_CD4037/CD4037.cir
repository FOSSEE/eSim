* E:\FOSSEE\eSim\library\SubcircuitLibrary\CD4037\CD4037.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/17/25 12:21:30

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U3  Net-_U1-Pad1_ Net-_U3-Pad2_ d_inverter
U5  Net-_U1-Pad5_ Net-_U3-Pad2_ Net-_U22-Pad1_ d_and
U6  Net-_U1-Pad1_ Net-_U1-Pad4_ Net-_U22-Pad2_ d_and
U7  Net-_U1-Pad5_ Net-_U1-Pad1_ Net-_U21-Pad1_ d_and
U8  Net-_U1-Pad4_ Net-_U3-Pad2_ Net-_U21-Pad2_ d_and
U22  Net-_U22-Pad1_ Net-_U22-Pad2_ Net-_U22-Pad3_ d_or
U21  Net-_U21-Pad1_ Net-_U21-Pad2_ Net-_U21-Pad3_ d_or
U23  Net-_U22-Pad3_ Net-_U1-Pad6_ d_inverter
U24  Net-_U21-Pad3_ Net-_U1-Pad7_ d_inverter
U9  Net-_U1-Pad5_ Net-_U12-Pad2_ Net-_U19-Pad1_ d_and
U10  Net-_U1-Pad2_ Net-_U1-Pad4_ Net-_U10-Pad3_ d_and
U11  Net-_U1-Pad5_ Net-_U1-Pad2_ Net-_U11-Pad3_ d_and
U12  Net-_U1-Pad4_ Net-_U12-Pad2_ Net-_U12-Pad3_ d_and
U19  Net-_U19-Pad1_ Net-_U10-Pad3_ Net-_U19-Pad3_ d_or
U20  Net-_U11-Pad3_ Net-_U12-Pad3_ Net-_U20-Pad3_ d_or
U25  Net-_U19-Pad3_ Net-_U1-Pad8_ d_inverter
U26  Net-_U20-Pad3_ Net-_U1-Pad9_ d_inverter
U2  Net-_U1-Pad2_ Net-_U12-Pad2_ d_inverter
U13  Net-_U1-Pad5_ Net-_U13-Pad2_ Net-_U13-Pad3_ d_and
U14  Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U14-Pad3_ d_and
U15  Net-_U1-Pad5_ Net-_U1-Pad3_ Net-_U15-Pad3_ d_and
U16  Net-_U1-Pad4_ Net-_U13-Pad2_ Net-_U16-Pad3_ d_and
U17  Net-_U13-Pad3_ Net-_U14-Pad3_ Net-_U17-Pad3_ d_or
U18  Net-_U15-Pad3_ Net-_U16-Pad3_ Net-_U18-Pad3_ d_or
U27  Net-_U17-Pad3_ Net-_U1-Pad10_ d_inverter
U28  Net-_U18-Pad3_ Net-_U1-Pad11_ d_inverter
U4  Net-_U1-Pad3_ Net-_U13-Pad2_ d_inverter
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ PORT

.end
