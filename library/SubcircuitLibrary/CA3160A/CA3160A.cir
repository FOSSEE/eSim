* C:\FOSSEE\eSim\library\SubcircuitLibrary\CA3160A\CA3160A.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 04/26/25 14:47:26

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
D2  Net-_D1-Pad2_ Net-_D2-Pad2_ eSim_Diode
D3  Net-_D2-Pad2_ Net-_D3-Pad2_ eSim_Diode
D4  Net-_D3-Pad2_ Net-_D4-Pad2_ eSim_Diode
R2  Net-_R2-Pad1_ Net-_D4-Pad2_ 40k
U2  Net-_R2-Pad1_ Net-_R1-Pad2_ zener
R3  Net-_R2-Pad1_ Net-_M8-Pad3_ 5k
M1  Net-_D1-Pad1_ Net-_D1-Pad1_ Net-_M1-Pad3_ Net-_M1-Pad3_ eSim_MOS_P
M3  Net-_M3-Pad1_ Net-_D1-Pad1_ Net-_M1-Pad3_ Net-_M1-Pad3_ eSim_MOS_P
M4  Net-_M2-Pad3_ Net-_D4-Pad2_ Net-_M3-Pad1_ Net-_M3-Pad1_ eSim_MOS_P
M6  Net-_M6-Pad1_ Net-_D1-Pad1_ Net-_M1-Pad3_ Net-_M1-Pad3_ eSim_MOS_P
M7  Net-_M7-Pad1_ Net-_D4-Pad2_ Net-_M6-Pad1_ Net-_M6-Pad1_ eSim_MOS_P
M2  Net-_M2-Pad1_ Net-_M2-Pad2_ Net-_M2-Pad3_ Net-_M2-Pad3_ eSim_MOS_P
M5  Net-_M5-Pad1_ Net-_M5-Pad2_ Net-_M2-Pad3_ Net-_M2-Pad3_ eSim_MOS_P
R5  Net-_M2-Pad1_ Net-_Q1-Pad1_ 1k
R7  Net-_M5-Pad1_ Net-_C1-Pad2_ 1k
Q1  Net-_Q1-Pad1_ Net-_M2-Pad1_ Net-_Q1-Pad3_ eSim_NPN
Q2  Net-_C1-Pad2_ Net-_M2-Pad1_ Net-_Q2-Pad3_ eSim_NPN
R6  Net-_Q1-Pad3_ Net-_M8-Pad3_ 1k
R8  Net-_Q2-Pad3_ Net-_M8-Pad3_ 1k
Q3  Net-_M7-Pad1_ Net-_C1-Pad2_ Net-_M8-Pad3_ eSim_NPN
M8  Net-_M8-Pad1_ Net-_M7-Pad1_ Net-_M8-Pad3_ Net-_M8-Pad3_ eSim_MOS_N
M9  Net-_M8-Pad1_ Net-_M7-Pad1_ Net-_M1-Pad3_ Net-_M1-Pad3_ eSim_MOS_P
U3  Net-_R4-Pad2_ Net-_M2-Pad2_ zener
U4  Net-_R4-Pad1_ Net-_M2-Pad3_ zener
R4  Net-_R4-Pad1_ Net-_R4-Pad2_ 10
R1  Net-_M1-Pad3_ Net-_R1-Pad2_ 10
D1  Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
U5  Net-_R4-Pad1_ Net-_M5-Pad2_ zener
R9  Net-_M7-Pad1_ Net-_C1-Pad1_ 2k
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 30p
U1  Net-_M2-Pad2_ Net-_M5-Pad2_ Net-_Q1-Pad3_ Net-_Q2-Pad3_ Net-_M7-Pad1_ Net-_M8-Pad3_ Net-_M8-Pad1_ Net-_M1-Pad3_ PORT

.end
