.title KiCad schematic
R1 Net-_D1-Pad2_ Net-_Q16-Pad1_ 100
R2 Net-_Q1-Pad1_ Net-_Q16-Pad1_ 500
R7 Net-_Q5-Pad3_ Net-_Q16-Pad1_ 100
R12 Net-_Q10-Pad3_ Net-_Q16-Pad1_ 100
Q5 Net-_Q10-Pad2_ Net-_Q10-Pad2_ Net-_Q5-Pad3_ eSim_PNP
Q10 Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_PNP
Q9 Net-_Q14-Pad1_ Net-_Q9-Pad2_ Net-_D1-Pad1_ eSim_NPN
Q11 Net-_Q11-Pad1_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_NPN
R10 Net-_Q7-Pad2_ Net-_Q11-Pad3_ 6k
D1 Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
Q3 Net-_Q3-Pad1_ Net-_Q3-Pad2_ Net-_D1-Pad1_ eSim_NPN
R5 Net-_D1-Pad1_ Net-_Q9-Pad2_ 500
Q1 Net-_Q1-Pad1_ Net-_D1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
R3 Net-_Q2-Pad2_ Net-_Q1-Pad3_ 3.3k
R4 Net-_Q9-Pad2_ Net-_Q2-Pad2_ 2.7k
Q6 Net-_Q10-Pad2_ Net-_Q11-Pad1_ Net-_Q6-Pad3_ eSim_NPN
Q2 Net-_Q10-Pad2_ Net-_Q2-Pad2_ Net-_Q2-Pad3_ eSim_NPN
Q7 Net-_Q6-Pad3_ Net-_Q7-Pad2_ Net-_Q2-Pad3_ eSim_NPN
R6 Net-_Q3-Pad1_ Net-_Q2-Pad3_ 1.8k
D2 Net-_D2-Pad1_ Net-_D2-Pad2_ eSim_Diode
Q16 Net-_Q16-Pad1_ Net-_Q14-Pad1_ Net-_Q16-Pad3_ eSim_NPN
R15 Net-_D2-Pad2_ Net-_Q16-Pad1_ 10k
Q14 Net-_Q14-Pad1_ Net-_D2-Pad1_ Net-_Q14-Pad3_ eSim_NPN
R16 Net-_Q14-Pad3_ Net-_Q16-Pad3_ 200
R19 Net-_D1-Pad1_ Net-_Q11-Pad2_ 5k
R18 Net-_Q11-Pad2_ Net-_Q14-Pad3_ 0.25k
R17 Net-_D2-Pad1_ Net-_Q17-Pad3_ 240
U1 Net-_Q16-Pad1_ Net-_D1-Pad1_ Net-_Q14-Pad3_ PORT
R20 Net-_Q14-Pad3_ Net-_Q17-Pad3_ 0.2
Q17 Net-_Q16-Pad1_ Net-_Q16-Pad3_ Net-_Q17-Pad3_ eSim_NPN
R13 Net-_D1-Pad1_ Net-_Q12-Pad3_ 5k
Q13 Net-_C1-Pad2_ Net-_Q12-Pad3_ Net-_D1-Pad1_ eSim_NPN
Q15 Net-_Q10-Pad1_ Net-_Q12-Pad1_ Net-_D1-Pad1_ eSim_NPN
Q12 Net-_Q12-Pad1_ Net-_C1-Pad1_ Net-_Q12-Pad3_ eSim_NPN
R9 Net-_D1-Pad1_ Net-_Q8-Pad3_ 1k
Q8 Net-_C1-Pad1_ Net-_Q3-Pad2_ Net-_Q8-Pad3_ eSim_NPN
R8 Net-_D1-Pad1_ Net-_Q3-Pad2_ 6k
R14 Net-_Q12-Pad1_ Net-_Q10-Pad1_ 2k
R11 Net-_C1-Pad1_ Net-_Q7-Pad2_ 28k
Q4 Net-_Q2-Pad3_ Net-_Q3-Pad1_ Net-_Q3-Pad2_ eSim_NPN
C1 Net-_C1-Pad1_ Net-_C1-Pad2_ 30p
.end
