* C:\FOSSEE2\eSim\library\SubcircuitLibrary\SC_74F382\SC_74F382.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/29/25 14:38:39

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
X1  Net-_U9-Pad2_ Net-_U5-Pad2_ Net-_U19-Pad3_ Net-_U17-Pad3_ Net-_X1-Pad5_ 4_and
X7  Net-_U16-Pad3_ Net-_U19-Pad3_ Net-_U21-Pad2_ Net-_U5-Pad2_ Net-_U1-Pad3_ Net-_X31-Pad2_ 5_and
X2  Net-_U17-Pad3_ Net-_U21-Pad2_ Net-_U1-Pad4_ Net-_U9-Pad2_ Net-_X2-Pad5_ 4_and
X8  Net-_U9-Pad2_ Net-_U5-Pad2_ Net-_U16-Pad3_ Net-_U21-Pad2_ Net-_U23-Pad3_ Net-_X30-Pad1_ 5_and
X3  Net-_U17-Pad3_ Net-_U19-Pad3_ Net-_U5-Pad2_ Net-_U1-Pad3_ Net-_X3-Pad5_ 4_and
X4  Net-_U17-Pad3_ Net-_U19-Pad3_ Net-_U1-Pad4_ Net-_U9-Pad2_ Net-_X30-Pad3_ 4_and
X5  Net-_U16-Pad3_ Net-_U21-Pad2_ Net-_U1-Pad4_ Net-_U1-Pad3_ Net-_X30-Pad4_ 4_and
X31  Net-_X1-Pad5_ Net-_X31-Pad2_ Net-_X2-Pad5_ ? Net-_U25-Pad1_ 4_OR
X30  Net-_X30-Pad1_ Net-_X3-Pad5_ Net-_X30-Pad3_ Net-_X30-Pad4_ Net-_U24-Pad1_ 4_OR
U25  Net-_U25-Pad1_ Net-_U25-Pad2_ d_inverter
U24  Net-_U24-Pad1_ Net-_U24-Pad2_ d_inverter
X9  Net-_U11-Pad2_ Net-_U7-Pad2_ Net-_U19-Pad3_ Net-_U17-Pad3_ Net-_X33-Pad1_ 4_and
X14  Net-_U16-Pad3_ Net-_U19-Pad3_ Net-_U21-Pad2_ Net-_U7-Pad2_ Net-_U1-Pad1_ Net-_X14-Pad6_ 5_and
X10  Net-_U17-Pad3_ Net-_U21-Pad2_ Net-_U1-Pad2_ Net-_U11-Pad2_ Net-_X10-Pad5_ 4_and
X15  Net-_U11-Pad2_ Net-_U7-Pad2_ Net-_U16-Pad3_ Net-_U21-Pad2_ Net-_U23-Pad3_ Net-_X15-Pad6_ 5_and
X11  Net-_U17-Pad3_ Net-_U19-Pad3_ Net-_U7-Pad2_ Net-_U1-Pad1_ Net-_X11-Pad5_ 4_and
X12  Net-_U17-Pad3_ Net-_U19-Pad3_ Net-_U1-Pad2_ Net-_U11-Pad2_ Net-_X12-Pad5_ 4_and
X13  Net-_U16-Pad3_ Net-_U21-Pad2_ Net-_U1-Pad2_ Net-_U1-Pad1_ Net-_X13-Pad5_ 4_and
X33  Net-_X33-Pad1_ Net-_X14-Pad6_ Net-_X10-Pad5_ ? Net-_U27-Pad1_ 4_OR
X32  Net-_X15-Pad6_ Net-_X11-Pad5_ Net-_X12-Pad5_ Net-_X13-Pad5_ Net-_U26-Pad1_ 4_OR
U27  Net-_U27-Pad1_ Net-_U27-Pad2_ d_inverter
U26  Net-_U26-Pad1_ Net-_U26-Pad2_ d_inverter
U18  Net-_U16-Pad1_ Net-_U10-Pad1_ Net-_U18-Pad3_ d_and
U22  Net-_U16-Pad1_ Net-_U15-Pad2_ Net-_U22-Pad3_ d_and
U20  Net-_U10-Pad1_ Net-_U15-Pad2_ Net-_U20-Pad3_ d_and
U19  Net-_U16-Pad1_ Net-_U10-Pad2_ Net-_U19-Pad3_ d_nand
U16  Net-_U16-Pad1_ Net-_U10-Pad1_ Net-_U16-Pad3_ d_nand
U5  Net-_U1-Pad4_ Net-_U5-Pad2_ d_inverter
U33  Net-_U1-Pad15_ Net-_U32-Pad3_ Net-_U33-Pad3_ d_nand
U40  Net-_U33-Pad3_ Net-_U24-Pad2_ Net-_U1-Pad8_ d_xor
U9  Net-_U1-Pad3_ Net-_U9-Pad2_ d_inverter
U7  Net-_U1-Pad2_ Net-_U7-Pad2_ d_inverter
U11  Net-_U1-Pad1_ Net-_U11-Pad2_ d_inverter
X41  Net-_U1-Pad15_ Net-_U25-Pad2_ Net-_U32-Pad3_ Net-_U35-Pad1_ 3_and
X42  Net-_U25-Pad2_ Net-_U24-Pad2_ Net-_U32-Pad3_ Net-_U35-Pad2_ 3_and
U35  Net-_U35-Pad1_ Net-_U35-Pad2_ Net-_U35-Pad3_ d_nor
U39  Net-_U35-Pad3_ Net-_U26-Pad2_ Net-_U1-Pad9_ d_xor
X39  Net-_U1-Pad15_ Net-_U25-Pad2_ Net-_U27-Pad2_ Net-_U32-Pad3_ Net-_X39-Pad5_ 4_and
X40  Net-_U25-Pad2_ Net-_U27-Pad2_ Net-_U24-Pad2_ Net-_U32-Pad3_ Net-_X40-Pad5_ 4_and
X38  Net-_U27-Pad2_ Net-_U26-Pad2_ Net-_U32-Pad3_ Net-_X38-Pad4_ 3_and
X52  Net-_X39-Pad5_ Net-_X40-Pad5_ Net-_X38-Pad4_ ? Net-_U38-Pad1_ 4_OR
U38  Net-_U38-Pad1_ Net-_U38-Pad2_ d_inverter
U45  Net-_U38-Pad2_ Net-_U28-Pad2_ Net-_U1-Pad11_ d_xor
X16  Net-_U13-Pad2_ Net-_U6-Pad2_ Net-_U19-Pad3_ Net-_U17-Pad3_ Net-_X16-Pad5_ 4_and
X21  Net-_U16-Pad3_ Net-_U19-Pad3_ Net-_U21-Pad2_ Net-_U6-Pad2_ Net-_U1-Pad19_ Net-_X21-Pad6_ 5_and
X17  Net-_U17-Pad3_ Net-_U21-Pad2_ Net-_U1-Pad18_ Net-_U13-Pad2_ Net-_X17-Pad5_ 4_and
X22  Net-_U13-Pad2_ Net-_U6-Pad2_ Net-_U16-Pad3_ Net-_U21-Pad2_ Net-_U23-Pad3_ Net-_X22-Pad6_ 5_and
X18  Net-_U17-Pad3_ Net-_U19-Pad3_ Net-_U6-Pad2_ Net-_U1-Pad19_ Net-_X18-Pad5_ 4_and
X19  Net-_U17-Pad3_ Net-_U19-Pad3_ Net-_U1-Pad18_ Net-_U13-Pad2_ Net-_X19-Pad5_ 4_and
X20  Net-_U16-Pad3_ Net-_U21-Pad2_ Net-_U1-Pad18_ Net-_U1-Pad19_ Net-_X20-Pad5_ 4_and
X35  Net-_X16-Pad5_ Net-_X21-Pad6_ Net-_X17-Pad5_ ? Net-_U29-Pad1_ 4_OR
X34  Net-_X22-Pad6_ Net-_X18-Pad5_ Net-_X19-Pad5_ Net-_X20-Pad5_ Net-_U28-Pad1_ 4_OR
U29  Net-_U29-Pad1_ Net-_U29-Pad2_ d_inverter
U28  Net-_U28-Pad1_ Net-_U28-Pad2_ d_inverter
X23  Net-_U14-Pad2_ Net-_U12-Pad2_ Net-_U19-Pad3_ Net-_U17-Pad3_ Net-_X23-Pad5_ 4_and
X28  Net-_U16-Pad3_ Net-_U19-Pad3_ Net-_U21-Pad2_ Net-_U12-Pad2_ Net-_U1-Pad17_ Net-_X28-Pad6_ 5_and
X24  Net-_U17-Pad3_ Net-_U21-Pad2_ Net-_U1-Pad16_ Net-_U14-Pad2_ Net-_X24-Pad5_ 4_and
X29  Net-_U14-Pad2_ Net-_U12-Pad2_ Net-_U16-Pad3_ Net-_U21-Pad2_ Net-_U23-Pad3_ Net-_X29-Pad6_ 5_and
X25  Net-_U17-Pad3_ Net-_U19-Pad3_ Net-_U12-Pad2_ Net-_U1-Pad17_ Net-_X25-Pad5_ 4_and
X26  Net-_U17-Pad3_ Net-_U19-Pad3_ Net-_U1-Pad16_ Net-_U14-Pad2_ Net-_X26-Pad5_ 4_and
X27  Net-_U16-Pad3_ Net-_U21-Pad2_ Net-_U1-Pad16_ Net-_U1-Pad17_ Net-_X27-Pad5_ 4_and
X37  Net-_X23-Pad5_ Net-_X28-Pad6_ Net-_X24-Pad5_ ? Net-_U31-Pad1_ 4_OR
X36  Net-_X29-Pad6_ Net-_X25-Pad5_ Net-_X26-Pad5_ Net-_X27-Pad5_ Net-_U30-Pad1_ 4_OR
U31  Net-_U31-Pad1_ Net-_U31-Pad2_ d_inverter
U30  Net-_U30-Pad1_ Net-_U30-Pad2_ d_inverter
U6  Net-_U1-Pad18_ Net-_U6-Pad2_ d_inverter
U13  Net-_U1-Pad19_ Net-_U13-Pad2_ d_inverter
U12  Net-_U1-Pad16_ Net-_U12-Pad2_ d_inverter
U14  Net-_U1-Pad17_ Net-_U14-Pad2_ d_inverter
U2  Net-_U1-Pad5_ Net-_U16-Pad1_ d_inverter
U8  Net-_U16-Pad1_ Net-_U8-Pad2_ d_inverter
U3  Net-_U1-Pad6_ Net-_U10-Pad1_ d_inverter
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ d_inverter
U4  Net-_U1-Pad7_ Net-_U15-Pad1_ d_inverter
U15  Net-_U15-Pad1_ Net-_U15-Pad2_ d_inverter
U32  Net-_U18-Pad3_ Net-_U15-Pad2_ Net-_U32-Pad3_ d_xor
U17  Net-_U10-Pad1_ Net-_U15-Pad1_ Net-_U17-Pad3_ d_nand
X6  Net-_U8-Pad2_ Net-_U10-Pad2_ Net-_U15-Pad1_ Net-_U21-Pad1_ 3_and
U21  Net-_U21-Pad1_ Net-_U21-Pad2_ d_inverter
U23  Net-_U22-Pad3_ Net-_U20-Pad3_ Net-_U23-Pad3_ d_nor
X47  Net-_U1-Pad15_ Net-_U25-Pad2_ Net-_U27-Pad2_ Net-_U29-Pad2_ Net-_U32-Pad3_ Net-_X47-Pad6_ 5_and
X48  Net-_U25-Pad2_ Net-_U27-Pad2_ Net-_U29-Pad2_ Net-_U24-Pad2_ Net-_U32-Pad3_ Net-_X48-Pad6_ 5_and
X44  Net-_U27-Pad2_ Net-_U29-Pad2_ Net-_U26-Pad2_ Net-_U32-Pad3_ Net-_X44-Pad5_ 4_and
X43  Net-_U29-Pad2_ Net-_U28-Pad2_ Net-_U32-Pad3_ Net-_X43-Pad4_ 3_and
X54  Net-_X47-Pad6_ Net-_X48-Pad6_ Net-_X44-Pad5_ Net-_X43-Pad4_ Net-_U43-Pad1_ 4_OR
U43  Net-_U43-Pad1_ Net-_U43-Pad2_ d_inverter
U46  Net-_U43-Pad2_ Net-_U30-Pad2_ Net-_U1-Pad12_ d_xor
U47  Net-_U43-Pad2_ Net-_U42-Pad3_ Net-_U1-Pad13_ d_xor
X45  Net-_U25-Pad2_ Net-_U27-Pad2_ Net-_U29-Pad2_ Net-_U31-Pad2_ Net-_U37-Pad1_ 4_and
U37  Net-_U37-Pad1_ ? d_inverter
X49  Net-_U25-Pad2_ Net-_U27-Pad2_ Net-_U29-Pad2_ Net-_U31-Pad2_ Net-_U24-Pad2_ Net-_X49-Pad6_ 5_and
X50  Net-_U27-Pad2_ Net-_U29-Pad2_ Net-_U31-Pad2_ Net-_U26-Pad2_ Net-_X50-Pad5_ 4_and
X46  Net-_U29-Pad2_ Net-_U31-Pad2_ Net-_U28-Pad2_ Net-_X46-Pad4_ 3_and
U34  Net-_U31-Pad2_ Net-_U30-Pad2_ Net-_U34-Pad3_ d_and
U36  Net-_U36-Pad1_ Net-_U36-Pad2_ d_inverter
U44  Net-_U41-Pad2_ Net-_U36-Pad2_ Net-_U1-Pad14_ d_nand
U42  Net-_U41-Pad2_ Net-_U36-Pad2_ Net-_U42-Pad3_ d_and
X53  Net-_X49-Pad6_ Net-_X50-Pad5_ Net-_X46-Pad4_ Net-_U34-Pad3_ Net-_U41-Pad1_ 4_OR
U41  Net-_U41-Pad1_ Net-_U41-Pad2_ d_inverter
X51  Net-_U1-Pad15_ Net-_U25-Pad2_ Net-_U27-Pad2_ Net-_U29-Pad2_ Net-_U31-Pad2_ Net-_U36-Pad1_ 5_and
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ ? Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ Net-_U1-Pad16_ Net-_U1-Pad17_ Net-_U1-Pad18_ Net-_U1-Pad19_ ? PORT

.end
