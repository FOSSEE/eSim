.title KiCad schematic
U1 Net-_Q1-Pad2_ unconnected-_U1-Pad2_ Net-_R1-Pad1_ Net-_R10-Pad1_ Net-_Q17-Pad3_ Net-_Q16-Pad3_ Net-_Q15-Pad3_ Net-_R19-Pad2_ Net-_Q1-Pad1_ Net-_Q12-Pad2_ PORT
R15 Net-_Q16-Pad3_ Net-_Q16-Pad2_ 2.7k
Q16 Net-_Q15-Pad3_ Net-_Q16-Pad2_ Net-_Q16-Pad3_ eSim_NPN
Q15 Net-_Q15-Pad1_ Net-_Q13-Pad1_ Net-_Q15-Pad3_ eSim_NPN
R16 Net-_Q15-Pad1_ Net-_Q1-Pad1_ 400
R14 Net-_Q13-Pad3_ Net-_Q15-Pad1_ 200
R19 Net-_Q15-Pad3_ Net-_R19-Pad2_ 10k
R10 Net-_R10-Pad1_ Net-_Q17-Pad3_ 2k
R11 Net-_Q11-Pad3_ Net-_R10-Pad1_ 3.6k
Q14 Net-_Q14-Pad1_ Net-_Q11-Pad2_ Net-_Q14-Pad3_ eSim_NPN
Q11 Net-_Q10-Pad2_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_NPN
Q10 Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
R13 Net-_Q17-Pad3_ Net-_Q14-Pad3_ 110
Q17 Net-_Q11-Pad2_ Net-_Q17-Pad2_ Net-_Q17-Pad3_ eSim_NPN
R17 Net-_Q17-Pad2_ Net-_Q16-Pad3_ 19k
R18 Net-_Q11-Pad2_ Net-_Q17-Pad2_ 52
Q7 Net-_Q10-Pad3_ Net-_Q11-Pad2_ Net-_Q7-Pad3_ eSim_NPN
R6 Net-_Q17-Pad3_ Net-_Q7-Pad3_ 110
R4 Net-_Q17-Pad3_ Net-_R1-Pad1_ 2k
R1 Net-_R1-Pad1_ Net-_Q2-Pad3_ 3.6k
Q2 Net-_Q1-Pad3_ Net-_Q11-Pad2_ Net-_Q2-Pad3_ eSim_NPN
Q12 Net-_Q1-Pad1_ Net-_Q12-Pad2_ Net-_Q10-Pad2_ eSim_NPN
Q9 Net-_Q13-Pad3_ Net-_Q8-Pad1_ Net-_Q5-Pad3_ eSim_NPN
R8 Net-_Q8-Pad1_ Net-_R5-Pad1_ 3.5k
Q8 Net-_Q8-Pad1_ Net-_Q10-Pad1_ Net-_Q14-Pad1_ eSim_NPN
R12 Net-_Q13-Pad1_ Net-_Q16-Pad2_ 740
R9 Net-_Q10-Pad1_ Net-_Q5-Pad3_ 3.5k
Q13 Net-_Q13-Pad1_ Net-_Q13-Pad2_ Net-_Q13-Pad3_ eSim_PNP
Q4 Net-_Q1-Pad1_ Net-_Q1-Pad1_ Net-_Q4-Pad3_ eSim_NPN
R2 Net-_Q13-Pad2_ Net-_Q4-Pad3_ 2.4k
Q5 Net-_Q13-Pad2_ Net-_Q5-Pad2_ Net-_Q5-Pad3_ eSim_NPN
R5 Net-_R5-Pad1_ Net-_Q5-Pad2_ 3.5k
R7 Net-_R5-Pad1_ Net-_Q1-Pad1_ 6k
Q1 Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
Q3 Net-_Q3-Pad1_ Net-_Q1-Pad3_ Net-_Q10-Pad3_ eSim_NPN
Q6 Net-_Q5-Pad2_ Net-_Q3-Pad1_ Net-_Q14-Pad1_ eSim_NPN
R3 Net-_Q3-Pad1_ Net-_Q5-Pad3_ 3.5k
.end
