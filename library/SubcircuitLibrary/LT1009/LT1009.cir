* C:\FOSSEE\eSim\library\SubcircuitLibrary\LT1009\LT1009.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 03/04/25 15:46:52

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
Q14  Net-_Q11-Pad2_ Net-_Q11-Pad2_ Anode eSim_NPN
Q7  Net-_Q5-Pad2_ Net-_Q10-Pad1_ Net-_Q4-Pad3_ eSim_PNP
Q9  Net-_Q4-Pad3_ Net-_Q15-Pad1_ cathode eSim_PNP
Q4  Net-_C2-Pad1_ Net-_C2-Pad2_ Net-_Q4-Pad3_ eSim_PNP
Q5  Net-_C2-Pad1_ Net-_Q5-Pad2_ Net-_Q3-Pad2_ eSim_NPN
Q2  cathode Net-_C2-Pad1_ Net-_Q1-Pad2_ eSim_NPN
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
Q11  Net-_Q10-Pad3_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_NPN
Q8  Net-_Q5-Pad2_ Net-_Q5-Pad2_ Net-_Q3-Pad2_ eSim_NPN
Q3  Net-_Q1-Pad2_ Net-_Q3-Pad2_ Anode eSim_NPN
Q12  Net-_C2-Pad2_ Net-_Q12-Pad2_ Net-_Q10-Pad3_ eSim_NPN
Q13  cathode cathode Net-_Q13-Pad3_ eSim_NPN
Q1  cathode Net-_Q1-Pad2_ Anode eSim_NPN
Q6  Net-_Q3-Pad2_ Net-_Q3-Pad2_ Anode eSim_NPN
C1  Net-_C1-Pad1_ cathode 20p
R1  Net-_C1-Pad1_ Net-_C2-Pad1_ 10k
C2  Net-_C2-Pad1_ Net-_C2-Pad2_ 30p
R2  Net-_Q10-Pad1_ Net-_Q15-Pad1_ 24k
R3  Anode Net-_Q11-Pad3_ 720
R4  Net-_C2-Pad2_ Net-_Q15-Pad1_ 24k
R7  Net-_Q11-Pad2_ Net-_Q10-Pad2_ 6.6k
R5  Net-_Q12-Pad2_ Net-_Q13-Pad3_ 6.6k
R8  Net-_Q10-Pad2_ ADJ 30k
R6  Net-_Q10-Pad2_ Net-_Q12-Pad2_ 500
U1  Anode ADJ cathode PORT
Q15  Net-_Q15-Pad1_ Net-_Q15-Pad1_ cathode eSim_PNP

.end
