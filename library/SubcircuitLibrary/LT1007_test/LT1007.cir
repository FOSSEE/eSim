.title KiCad schematic
Q29 Net-_I1-Pad2_ Net-_I5-Pad1_ Net-_Q28-Pad2_ eSim_PNP
U1 Net-_R1-Pad1_ Net-_D1-Pad2_ Net-_D1-Pad1_ Net-_I1-Pad2_ unconnected-_U1-Pad5_ Net-_Q27-Pad3_ Net-_C1-Pad1_ Net-_R3-Pad1_ PORT
I5 Net-_I5-Pad1_ Net-_I1-Pad2_ 500uA
I6 Net-_C1-Pad1_ Net-_I6-Pad2_ 240uA
C3 Net-_C3-Pad1_ Net-_C3-Pad2_ 110p
I4 Net-_C1-Pad1_ Net-_C3-Pad2_ 750uA
R14 Net-_Q27-Pad3_ Net-_Q27-Pad2_ 20
Q27 Net-_I6-Pad2_ Net-_Q27-Pad2_ Net-_Q27-Pad3_ eSim_NPN
Q30 Net-_C1-Pad1_ Net-_I6-Pad2_ Net-_Q27-Pad2_ eSim_NPN
Q19 Net-_C1-Pad1_ Net-_Q17-Pad1_ Net-_Q18-Pad2_ eSim_NPN
Q17 Net-_Q17-Pad1_ Net-_Q14-Pad3_ Net-_Q17-Pad3_ eSim_PNP
Q21 Net-_C2-Pad2_ Net-_Q16-Pad1_ Net-_Q21-Pad3_ eSim_PNP
R9 Net-_Q21-Pad3_ Net-_I3-Pad2_ 1.2k
R12 Net-_Q10-Pad1_ Net-_C3-Pad1_ 750
Q22 Net-_C1-Pad1_ Net-_C1-Pad2_ Net-_Q16-Pad1_ eSim_NPN
C2 Net-_C2-Pad1_ Net-_C2-Pad2_ 80p
R11 Net-_C2-Pad1_ Net-_Q10-Pad1_ 200
C4 Net-_C2-Pad2_ Net-_C3-Pad2_ 20p
I3 Net-_C1-Pad1_ Net-_I3-Pad2_ 450uA
Q20 Net-_C2-Pad2_ Net-_Q18-Pad2_ Net-_Q20-Pad3_ eSim_NPN
R13 Net-_I1-Pad2_ Net-_Q24-Pad3_ 50
R10 Net-_I1-Pad2_ Net-_Q23-Pad3_ 6k
Q24 Net-_C3-Pad2_ Net-_Q23-Pad3_ Net-_Q24-Pad3_ eSim_NPN
R7 Net-_I1-Pad2_ Net-_Q18-Pad2_ 6k
R8 Net-_I1-Pad2_ Net-_Q20-Pad3_ 200
Q23 Net-_C1-Pad1_ Net-_C2-Pad2_ Net-_Q23-Pad3_ eSim_NPN
Q28 Net-_I5-Pad1_ Net-_Q28-Pad2_ Net-_Q27-Pad3_ eSim_PNP
R15 Net-_Q28-Pad2_ Net-_Q27-Pad3_ 20
Q26 Net-_I1-Pad2_ Net-_C3-Pad2_ Net-_I6-Pad2_ eSim_PNP
Q25 Net-_C1-Pad1_ Net-_C3-Pad2_ Net-_I5-Pad1_ eSim_NPN
Q15 Net-_Q14-Pad3_ Net-_Q15-Pad2_ Net-_I2-Pad1_ eSim_NPN
Q16 Net-_Q16-Pad1_ Net-_Q15-Pad2_ Net-_I2-Pad1_ eSim_NPN
Q18 Net-_Q17-Pad1_ Net-_Q18-Pad2_ Net-_Q18-Pad3_ eSim_NPN
I2 Net-_I2-Pad1_ Net-_I1-Pad2_ 120uA
R5 Net-_I1-Pad2_ Net-_Q18-Pad3_ 200
Q8 Net-_Q6-Pad2_ Net-_Q1-Pad2_ Net-_Q5-Pad2_ eSim_PNP
I1 Net-_I1-Pad1_ Net-_I1-Pad2_ 240uA
Q14 Net-_C1-Pad1_ Net-_Q10-Pad1_ Net-_Q14-Pad3_ eSim_NPN
R6 Net-_Q17-Pad3_ Net-_I3-Pad2_ 1.2k
Q3 Net-_D1-Pad1_ Net-_Q1-Pad2_ Net-_Q3-Pad3_ eSim_PNP
Q10 Net-_Q10-Pad1_ Net-_D1-Pad1_ Net-_I1-Pad1_ eSim_NPN
R4 Net-_C1-Pad2_ Net-_R3-Pad1_ 17k
C1 Net-_C1-Pad1_ Net-_C1-Pad2_ 130p
R1 Net-_R1-Pad1_ Net-_C1-Pad1_ 3.4k
R2 Net-_Q10-Pad1_ Net-_R1-Pad1_ 17k
R3 Net-_R3-Pad1_ Net-_C1-Pad1_ 3.4k
Q5 Net-_I1-Pad2_ Net-_Q5-Pad2_ Net-_Q2-Pad2_ eSim_PNP
Q7 Net-_Q5-Pad2_ Net-_Q2-Pad2_ Net-_C1-Pad1_ eSim_PNP
Q2 Net-_Q1-Pad3_ Net-_Q2-Pad2_ Net-_C1-Pad1_ eSim_PNP
Q4 Net-_Q3-Pad3_ Net-_Q2-Pad2_ Net-_C1-Pad1_ eSim_PNP
Q12 Net-_C1-Pad2_ Net-_D1-Pad2_ Net-_I1-Pad1_ eSim_NPN
Q11 Net-_Q10-Pad1_ Net-_D1-Pad1_ Net-_I1-Pad1_ eSim_NPN
Q13 Net-_C1-Pad2_ Net-_D1-Pad2_ Net-_I1-Pad1_ eSim_NPN
Q6 Net-_I1-Pad2_ Net-_Q6-Pad2_ Net-_Q1-Pad2_ eSim_PNP
Q1 Net-_D1-Pad2_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_PNP
D2 Net-_D1-Pad2_ Net-_D1-Pad1_ eSim_Diode
Q9 Net-_Q6-Pad2_ Net-_I1-Pad1_ Net-_Q15-Pad2_ eSim_NPN
D1 Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
.end
