* /home/vsduser/Downloads/eSim-2.3/library/SubcircuitLibrary/SerialParallel_blk/SerialParallel_blk.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: Thu Jul 10 18:13:44 2025

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
X5  Net-_U1-Pad7_ Net-_X13-Pad7_ Net-_U1-Pad1_ Net-_U1-Pad3_ Net-_U1-Pad8_ Net-_U1-Pad6_ Net-_X5-Pad7_ 4_in_and
X3  Net-_U1-Pad3_ Net-_U1-Pad5_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad4_ Net-_X3-Pad6_ 3_in_and
X8  Net-_X5-Pad7_ Net-_X3-Pad6_ Net-_X11-Pad3_ Net-_U1-Pad8_ Net-_U1-Pad7_ Net-_X10-Pad4_ NOR_3
X6  Net-_U1-Pad7_ Net-_X1-Pad4_ Net-_U1-Pad9_ Net-_U1-Pad3_ Net-_U1-Pad8_ Net-_U1-Pad6_ Net-_X6-Pad7_ 4_in_and
X4  Net-_U1-Pad3_ Net-_U1-Pad5_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_X2-Pad4_ Net-_X4-Pad6_ 3_in_and
X9  Net-_X11-Pad4_ Net-_X6-Pad7_ Net-_X10-Pad3_ Net-_U1-Pad8_ Net-_U1-Pad7_ Net-_X4-Pad6_ NOR_3
X10  Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_X10-Pad3_ Net-_X10-Pad4_ CMOS_Buf
X11  Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_X11-Pad3_ Net-_X11-Pad4_ CMOS_Buf
X12  Net-_X12-Pad1_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_X12-Pad4_ CMOS_INVTR
X7  Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad3_ Net-_X12-Pad1_ CMOS_Buf
X13  Net-_X10-Pad3_ Net-_X12-Pad4_ Net-_X11-Pad3_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_X13-Pad7_ SRFF
X1  Net-_U1-Pad2_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_X1-Pad4_ CMOS_INVTR
X2  Net-_U1-Pad4_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_X2-Pad4_ CMOS_INVTR
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ PORT
scmode1  SKY130mode

.end
