* C:\FOSSEE\eSim\library\SubcircuitLibrary\tc4008bp_ic\tc4008bp_ic.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 07/09/25 23:55:17

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U7  Net-_U1-Pad1_ Net-_U1-Pad15_ Net-_U16-Pad1_ d_nor
U8  Net-_U1-Pad1_ Net-_U1-Pad15_ Net-_U11-Pad1_ d_nand
U11  Net-_U11-Pad1_ Net-_U11-Pad2_ d_inverter
U16  Net-_U16-Pad1_ Net-_U11-Pad2_ Net-_U16-Pad3_ d_nor
U20  Net-_U16-Pad3_ Net-_U20-Pad2_ Net-_U20-Pad3_ d_xor
U30  Net-_U20-Pad3_ Net-_U1-Pad13_ d_inverter
U50  Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U12-Pad1_ d_nor
U2  Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U14-Pad2_ d_nand
U12  Net-_U12-Pad1_ Net-_U12-Pad2_ d_inverter
U14  Net-_U12-Pad2_ Net-_U14-Pad2_ Net-_U14-Pad3_ d_nand
U23  Net-_U12-Pad2_ Net-_U23-Pad2_ Net-_U23-Pad3_ d_and
U33  Net-_U21-Pad2_ Net-_U23-Pad3_ Net-_U20-Pad2_ d_nor
U21  Net-_U14-Pad2_ Net-_U21-Pad2_ d_inverter
U24  Net-_U14-Pad3_ Net-_U23-Pad2_ Net-_U24-Pad3_ d_xor
U34  Net-_U24-Pad3_ Net-_U1-Pad12_ d_inverter
U3  Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U15-Pad1_ d_nor
U4  Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U22-Pad1_ d_nand
U9  Net-_U22-Pad1_ Net-_U15-Pad2_ d_inverter
U15  Net-_U15-Pad1_ Net-_U15-Pad2_ Net-_U15-Pad3_ d_nor
U26  Net-_U15-Pad1_ Net-_U26-Pad2_ Net-_U26-Pad3_ d_or
U27  Net-_U15-Pad3_ Net-_U26-Pad2_ Net-_U27-Pad3_ d_xor
U35  Net-_U22-Pad1_ Net-_U26-Pad3_ Net-_U23-Pad2_ d_nand
U36  Net-_U27-Pad3_ Net-_U1-Pad11_ d_inverter
U5  Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U10-Pad1_ d_nor
U6  Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U13-Pad2_ d_nand
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ d_inverter
U13  Net-_U10-Pad2_ Net-_U13-Pad2_ Net-_U13-Pad3_ d_nand
U25  Net-_U10-Pad2_ Net-_U1-Pad9_ Net-_U25-Pad3_ d_and
U37  Net-_U29-Pad2_ Net-_U25-Pad3_ Net-_U26-Pad2_ d_nor
U29  Net-_U13-Pad2_ Net-_U29-Pad2_ d_inverter
U28  Net-_U13-Pad3_ Net-_U1-Pad9_ Net-_U28-Pad3_ d_xor
U38  Net-_U28-Pad3_ Net-_U1-Pad10_ d_inverter
U17  Net-_U15-Pad1_ Net-_U13-Pad2_ Net-_U17-Pad3_ d_or
U22  Net-_U22-Pad1_ Net-_U17-Pad3_ Net-_U22-Pad3_ d_and
U32  Net-_U12-Pad1_ Net-_U22-Pad3_ Net-_U32-Pad3_ d_or
U39  Net-_U14-Pad2_ Net-_U32-Pad3_ Net-_U39-Pad3_ d_and
U41  Net-_U16-Pad1_ Net-_U39-Pad3_ Net-_U41-Pad3_ d_or
U42  Net-_U11-Pad1_ Net-_U41-Pad3_ Net-_U42-Pad3_ d_nand
U43  Net-_U40-Pad3_ Net-_U42-Pad3_ Net-_U43-Pad3_ d_nor
U44  Net-_U43-Pad3_ Net-_U1-Pad14_ d_inverter
U19  Net-_U15-Pad1_ Net-_U10-Pad1_ Net-_U19-Pad3_ d_nor
U18  Net-_U16-Pad1_ Net-_U12-Pad1_ Net-_U18-Pad3_ d_nor
U31  Net-_U18-Pad3_ Net-_U19-Pad3_ Net-_U31-Pad3_ d_nor
U40  Net-_U1-Pad9_ Net-_U31-Pad3_ Net-_U40-Pad3_ d_and
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ PORT

.end
