.title KiCad schematic
Q34 Net-_Q29-Pad2_ Net-_Q31-Pad3_ Net-_J1-Pad2_ eSim_NPN
U1 Net-_C2-Pad1_ Net-_Q1-Pad1_ Net-_Q2-Pad3_ Net-_J1-Pad2_ Net-_C1-Pad2_ Net-_Q35-Pad3_ Net-_C1-Pad1_ Net-_C3-Pad2_ PORT
Q38 Net-_Q37-Pad2_ Net-_Q31-Pad3_ Net-_Q38-Pad3_ eSim_NPN
R23 Net-_J1-Pad2_ Net-_Q38-Pad3_ 30
Q32 Net-_Q30-Pad1_ Net-_Q30-Pad3_ Net-_Q29-Pad2_ eSim_NPN
R19 Net-_Q29-Pad2_ Net-_Q30-Pad3_ 5k
Q28 Net-_Q27-Pad2_ Net-_Q27-Pad2_ Net-_C1-Pad1_ eSim_PNP
Q27 Net-_C2-Pad2_ Net-_Q27-Pad2_ Net-_C1-Pad1_ eSim_PNP
Q36 Net-_Q33-Pad2_ Net-_Q33-Pad2_ Net-_Q29-Pad2_ eSim_NPN
R22 Net-_Q37-Pad2_ Net-_Q37-Pad1_ 30
Q37 Net-_Q37-Pad1_ Net-_Q37-Pad2_ Net-_Q37-Pad3_ eSim_PNP
Q41 Net-_J1-Pad2_ Net-_Q37-Pad1_ Net-_Q33-Pad2_ eSim_PNP
R24 Net-_Q33-Pad2_ Net-_Q35-Pad2_ 33
Q33 Net-_Q21-Pad1_ Net-_Q33-Pad2_ Net-_Q33-Pad3_ eSim_PNP
Q30 Net-_Q30-Pad1_ Net-_C2-Pad2_ Net-_Q30-Pad3_ eSim_NPN
R21 Net-_Q33-Pad3_ Net-_Q35-Pad2_ 3.5k
R25 Net-_Q35-Pad2_ Net-_Q35-Pad3_ 25
Q40 Net-_C1-Pad1_ Net-_Q30-Pad1_ Net-_Q35-Pad2_ eSim_NPN
R18 Net-_Q30-Pad1_ Net-_C2-Pad2_ 13
Q35 Net-_Q30-Pad1_ Net-_Q35-Pad2_ Net-_Q35-Pad3_ eSim_NPN
Q39 Net-_C1-Pad1_ Net-_Q30-Pad1_ Net-_Q37-Pad3_ eSim_NPN
R20 Net-_J1-Pad2_ Net-_Q31-Pad3_ 1.2k
Q29 Net-_J1-Pad2_ Net-_Q29-Pad2_ Net-_C3-Pad2_ eSim_PNP
Q31 Net-_C1-Pad1_ Net-_C3-Pad2_ Net-_Q31-Pad3_ eSim_NPN
Q25 Net-_C3-Pad2_ Net-_Q22-Pad2_ Net-_J1-Pad2_ eSim_NPN
Q21 Net-_Q21-Pad1_ Net-_C2-Pad1_ Net-_Q21-Pad3_ eSim_PNP
R15 Net-_Q21-Pad3_ Net-_Q27-Pad2_ 6k
R7 Net-_C1-Pad1_ Net-_Q10-Pad2_ 150k
R5 Net-_C1-Pad2_ Net-_Q14-Pad1_ 20k
R12 Net-_Q14-Pad1_ Net-_C2-Pad1_ 20k
Q14 Net-_Q14-Pad1_ Net-_Q14-Pad1_ Net-_Q10-Pad2_ eSim_PNP
Q17 Net-_C2-Pad1_ Net-_Q10-Pad2_ Net-_Q17-Pad3_ eSim_PNP
R13 Net-_C1-Pad1_ Net-_Q17-Pad3_ 2k
C2 Net-_C2-Pad1_ Net-_C2-Pad2_ 6p
Q20 Net-_C2-Pad1_ Net-_Q2-Pad3_ Net-_Q11-Pad3_ eSim_NPN
Q26 Net-_C3-Pad2_ Net-_C1-Pad2_ Net-_Q26-Pad3_ eSim_PNP
R17 Net-_Q26-Pad3_ Net-_Q27-Pad2_ 6k
Q13 Net-_C1-Pad2_ Net-_C1-Pad2_ Net-_C2-Pad1_ eSim_NPN
Q7 Net-_C1-Pad2_ Net-_Q1-Pad1_ Net-_Q12-Pad3_ eSim_NPN
Q15 Net-_C2-Pad1_ Net-_C2-Pad1_ Net-_C1-Pad2_ eSim_NPN
Q1 Net-_Q1-Pad1_ Net-_Q1-Pad1_ Net-_Q1-Pad3_ eSim_NPN
C1 Net-_C1-Pad1_ Net-_C1-Pad2_ 100p
Q10 Net-_C1-Pad2_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_PNP
R3 Net-_C1-Pad1_ Net-_Q10-Pad3_ 2k
Q6 Net-_Q6-Pad1_ Net-_Q4-Pad3_ Net-_J1-Pad2_ eSim_NPN
J1 Net-_C1-Pad1_ Net-_J1-Pad2_ Net-_J1-Pad3_ jfet_n
R14 Net-_J1-Pad2_ Net-_Q18-Pad3_ 110
R4 Net-_J1-Pad2_ Net-_Q18-Pad2_ 20k
Q18 Net-_Q11-Pad1_ Net-_Q18-Pad2_ Net-_Q18-Pad3_ eSim_NPN
Q9 Net-_C1-Pad1_ Net-_Q6-Pad1_ Net-_Q18-Pad2_ eSim_NPN
R2 Net-_Q6-Pad1_ Net-_J1-Pad3_ 500
Q2 Net-_Q1-Pad1_ Net-_Q1-Pad3_ Net-_Q2-Pad3_ eSim_NPN
Q3 Net-_Q2-Pad3_ Net-_Q3-Pad2_ Net-_Q1-Pad1_ eSim_NPN
Q5 Net-_Q2-Pad3_ Net-_Q2-Pad3_ Net-_Q3-Pad2_ eSim_NPN
Q4 Net-_C1-Pad1_ Net-_J1-Pad3_ Net-_Q4-Pad3_ eSim_NPN
R1 Net-_J1-Pad2_ Net-_Q4-Pad3_ 6.6k
Q23 Net-_C1-Pad1_ Net-_Q21-Pad1_ Net-_C3-Pad2_ eSim_NPN
Q24 Net-_C1-Pad1_ Net-_Q21-Pad1_ Net-_Q22-Pad2_ eSim_NPN
R16 Net-_J1-Pad2_ Net-_Q22-Pad2_ 1.2k
Q22 Net-_Q21-Pad1_ Net-_Q22-Pad2_ Net-_J1-Pad2_ eSim_NPN
C3 Net-_C2-Pad1_ Net-_C3-Pad2_ 28p
Q11 Net-_Q11-Pad1_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_NPN
Q12 Net-_Q11-Pad1_ Net-_Q11-Pad2_ Net-_Q12-Pad3_ eSim_NPN
Q8 Net-_C1-Pad2_ Net-_Q12-Pad3_ Net-_Q8-Pad3_ eSim_NPN
R6 Net-_Q8-Pad3_ Net-_Q16-Pad2_ 1k
R11 Net-_Q16-Pad2_ Net-_Q19-Pad3_ 1k
Q19 Net-_C2-Pad1_ Net-_Q11-Pad3_ Net-_Q19-Pad3_ eSim_NPN
R9 Net-_Q16-Pad1_ Net-_Q16-Pad2_ 50
R8 Net-_Q11-Pad2_ Net-_Q16-Pad1_ 1.7k
R10 Net-_Q11-Pad1_ Net-_Q16-Pad1_ 4k
Q16 Net-_Q16-Pad1_ Net-_Q16-Pad2_ Net-_Q11-Pad1_ eSim_NPN
.end
