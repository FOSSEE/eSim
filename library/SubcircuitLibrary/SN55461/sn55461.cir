* D:\FOSSEE\eSim\library\SubcircuitLibrary\sn55461\sn55461.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 02/16/25 19:21:55

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
R3  vcc Net-_Q4-Pad2_ 4k
R2  vcc Net-_Q1-Pad2_ 1.6k
R1  vcc Net-_Q1-Pad1_ 130
Q4  Net-_Q3-Pad2_ Net-_Q4-Pad2_ Net-_D3-Pad2_ eSim_NPN
Q5  Net-_Q3-Pad2_ Net-_Q4-Pad2_ Net-_D2-Pad2_ eSim_NPN
Q3  Net-_Q1-Pad2_ Net-_Q3-Pad2_ Net-_Q3-Pad3_ eSim_NPN
R8  Net-_Q3-Pad3_ gnd1 1k
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_D1-Pad1_ eSim_NPN
D3  gnd1 Net-_D3-Pad2_ eSim_Diode
D2  gnd1 Net-_D2-Pad2_ eSim_Diode
Q6  Net-_D1-Pad2_ Net-_Q3-Pad3_ gnd1 eSim_NPN
D1  Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
R4  Net-_D1-Pad2_ gnd1 500
Q2  Net-_Q2-Pad1_ Net-_D1-Pad2_ gnd1 eSim_NPN
U1  vcc Net-_Q2-Pad1_ Net-_D3-Pad2_ Net-_D2-Pad2_ Net-_Q8-Pad1_ Net-_D6-Pad2_ Net-_D5-Pad2_ gnd1 PORT
R7  vcc Net-_Q10-Pad2_ 4k
R6  vcc Net-_Q7-Pad2_ 1.6k
R5  vcc Net-_Q7-Pad1_ 130
Q11  Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_D6-Pad2_ eSim_NPN
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_D5-Pad2_ eSim_NPN
Q9  Net-_Q7-Pad2_ Net-_Q10-Pad1_ Net-_Q12-Pad2_ eSim_NPN
R10  Net-_Q12-Pad2_ gnd1 1k
Q7  Net-_Q7-Pad1_ Net-_Q7-Pad2_ Net-_D4-Pad1_ eSim_NPN
D6  gnd1 Net-_D6-Pad2_ eSim_Diode
D5  gnd1 Net-_D5-Pad2_ eSim_Diode
Q12  Net-_D4-Pad2_ Net-_Q12-Pad2_ gnd1 eSim_NPN
D4  Net-_D4-Pad1_ Net-_D4-Pad2_ eSim_Diode
R9  Net-_D4-Pad2_ gnd1 500
Q8  Net-_Q8-Pad1_ Net-_D4-Pad2_ gnd1 eSim_NPN

.end
