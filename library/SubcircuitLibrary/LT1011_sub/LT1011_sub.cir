* C:\FOSSEE\eSim\library\SubcircuitLibrary\LT1011_sub\LT1011_sub.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 07/07/24 17:05:56

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
R30  Net-_J2-Pad1_ Net-_Q35-Pad3_ 3k
Q35  Net-_D7-Pad2_ Net-_Q35-Pad2_ Net-_Q35-Pad3_ eSim_PNP
Q34  Net-_J2-Pad2_ Net-_D5-Pad2_ Net-_D7-Pad2_ eSim_PNP
Q37  Net-_J2-Pad2_ Net-_D6-Pad2_ Net-_D8-Pad2_ eSim_PNP
Q38  Net-_J2-Pad1_ Net-_J2-Pad1_ Net-_Q38-Pad3_ eSim_NPN
R31  Net-_Q38-Pad3_ Net-_Q35-Pad2_ 160
D7  Net-_D5-Pad1_ Net-_D7-Pad2_ eSim_Diode
Q39  Net-_Q35-Pad2_ Net-_D7-Pad2_ Net-_D5-Pad1_ eSim_NPN
R33  Net-_Q44-Pad3_ Net-_R33-Pad2_ 300
R43  Net-_Q53-Pad3_ Net-_Q50-Pad1_ 4k
R35  Net-_J2-Pad1_ Net-_Q44-Pad3_ 1.3k
R36  Net-_J2-Pad1_ Net-_Q45-Pad3_ 1.3k
Q44  Net-_Q43-Pad3_ Net-_Q35-Pad2_ Net-_Q44-Pad3_ eSim_PNP
Q45  Net-_Q35-Pad2_ Net-_Q35-Pad2_ Net-_Q45-Pad3_ eSim_PNP
U5  Net-_U5-PadIN_ Net-_Q43-Pad3_ zener
U6  Net-_U5-PadIN_ Net-_Q35-Pad2_ zener
Q43  Net-_J2-Pad2_ Net-_D5-Pad1_ Net-_Q43-Pad3_ eSim_PNP
Q41  Net-_Q35-Pad2_ Net-_D8-Pad2_ Net-_D5-Pad1_ eSim_NPN
D8  Net-_D5-Pad1_ Net-_D8-Pad2_ eSim_Diode
Q40  Net-_D5-Pad1_ Net-_Q40-Pad2_ Net-_Q40-Pad3_ eSim_NPN
Q42  Net-_D5-Pad1_ Net-_Q40-Pad2_ Net-_Q42-Pad3_ eSim_NPN
R34  Net-_Q42-Pad3_ Net-_J2-Pad2_ 1.6k
R42  Net-_Q51-Pad3_ Net-_J2-Pad2_ 275
R50  Net-_J2-Pad1_ Net-_Q54-Pad1_ 800
R39  Net-_Q54-Pad3_ Net-_Q45-Pad3_ 300
Q53  Net-_J2-Pad1_ Net-_Q50-Pad1_ Net-_Q53-Pad3_ eSim_NPN
Q58  Net-_Q58-Pad1_ Net-_Q53-Pad3_ Net-_Q54-Pad1_ eSim_PNP
R41  Net-_J2-Pad1_ Net-_Q50-Pad1_ 800
R32  Net-_Q40-Pad3_ Net-_J2-Pad2_ 1.6k
Q46  Net-_J2-Pad2_ Net-_D5-Pad1_ Net-_Q35-Pad2_ eSim_PNP
Q48  Net-_Q47-Pad3_ Net-_Q40-Pad2_ Net-_Q48-Pad3_ eSim_NPN
R38  Net-_Q47-Pad1_ Net-_Q35-Pad2_ 3.2k
Q47  Net-_Q47-Pad1_ Net-_Q43-Pad3_ Net-_Q47-Pad3_ eSim_NPN
R40  Net-_Q49-Pad1_ Net-_Q35-Pad2_ 3.2k
Q50  Net-_Q50-Pad1_ Net-_Q47-Pad1_ Net-_Q50-Pad3_ eSim_NPN
R37  Net-_Q48-Pad3_ Net-_J2-Pad2_ 500
Q51  Net-_Q50-Pad3_ Net-_Q40-Pad2_ Net-_Q51-Pad3_ eSim_NPN
Q49  Net-_Q49-Pad1_ Net-_Q35-Pad2_ Net-_Q47-Pad3_ eSim_NPN
Q54  Net-_Q54-Pad1_ Net-_Q54-Pad1_ Net-_Q54-Pad3_ eSim_NPN
Q56  Net-_Q54-Pad1_ Net-_Q49-Pad1_ Net-_Q50-Pad3_ eSim_NPN
R46  Net-_R46-Pad1_ Net-_Q40-Pad2_ 200
Q57  Net-_Q53-Pad3_ Net-_Q57-Pad2_ Net-_Q57-Pad3_ eSim_NPN
R48  Net-_R46-Pad1_ Net-_Q57-Pad3_ 800
R49  Net-_R45-Pad2_ Net-_R46-Pad1_ 700
R45  Net-_Q52-Pad2_ Net-_R45-Pad2_ 940
Q52  Net-_Q40-Pad2_ Net-_Q52-Pad2_ Net-_J2-Pad2_ eSim_NPN
Q55  Net-_Q55-Pad1_ Net-_Q55-Pad1_ Net-_J2-Pad2_ eSim_NPN
R44  Net-_Q52-Pad2_ Net-_Q55-Pad1_ 960
R47  Net-_R45-Pad2_ Net-_J2-Pad2_ 4.8k
Q65  Net-_J2-Pad1_ Net-_Q58-Pad1_ Net-_Q65-Pad3_ eSim_NPN
R54  Net-_Q65-Pad3_ Net-_Q66-Pad2_ 170
R53  Net-_Q58-Pad1_ Net-_Q65-Pad3_ 4k
Q66  Net-_Q64-Pad2_ Net-_Q66-Pad2_ Net-_Q62-Pad2_ eSim_NPN
J2  Net-_J2-Pad1_ Net-_J2-Pad2_ Net-_J2-Pad3_ jfet_n
Q59  Net-_Q57-Pad2_ Net-_J2-Pad3_ Net-_Q59-Pad3_ eSim_NPN
R51  Net-_Q57-Pad2_ Net-_J2-Pad3_ 200
Q60  Net-_Q59-Pad3_ Net-_Q59-Pad3_ Net-_Q60-Pad3_ eSim_NPN
Q61  Net-_Q60-Pad3_ Net-_Q60-Pad3_ Net-_J2-Pad2_ eSim_NPN
Q63  Net-_Q58-Pad1_ Net-_Q58-Pad1_ Net-_Q63-Pad3_ eSim_NPN
Q64  Net-_J2-Pad2_ Net-_Q64-Pad2_ Net-_Q63-Pad3_ eSim_PNP
R55  Net-_Q66-Pad2_ Net-_Q62-Pad2_ 470
Q62  Net-_Q58-Pad1_ Net-_Q62-Pad2_ Net-_Q62-Pad3_ eSim_NPN
R52  Net-_Q62-Pad3_ Net-_R52-Pad2_ 400
R57  Net-_Q62-Pad2_ Net-_R52-Pad2_ 4
Q36  Net-_D7-Pad2_ Net-_D8-Pad2_ Net-_Q35-Pad3_ eSim_PNP
D5  Net-_D5-Pad1_ Net-_D5-Pad2_ eSim_Diode
D6  Net-_D5-Pad1_ Net-_D6-Pad2_ eSim_Diode
U4  Net-_R52-Pad2_ Net-_D5-Pad2_ Net-_D6-Pad2_ Net-_J2-Pad2_ Net-_R33-Pad2_ Net-_Q54-Pad3_ Net-_Q64-Pad2_ Net-_J2-Pad1_ PORT

.end
