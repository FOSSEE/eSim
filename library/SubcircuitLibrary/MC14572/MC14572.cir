* C:\FOSSEE\eSim\library\SubcircuitLibrary\MC14572\MC14572.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 07/12/25 14:08:44

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
M7  Net-_M7-Pad1_ Net-_M7-Pad2_ GND GND mosfet_n
M8  Net-_M10-Pad1_ Net-_M7-Pad2_ Net-_M7-Pad1_ Net-_M10-Pad1_ mosfet_p
U1  Net-_M1-Pad1_ Net-_M1-Pad2_ Net-_M3-Pad1_ Net-_M3-Pad2_ Net-_M11-Pad3_ Net-_M10-Pad2_ Net-_M11-Pad2_ GND Net-_M5-Pad1_ Net-_M5-Pad2_ Net-_M7-Pad1_ Net-_M7-Pad2_ Net-_M13-Pad3_ Net-_M14-Pad2_ Net-_M13-Pad2_ Net-_M10-Pad1_ PORT
M10  Net-_M10-Pad1_ Net-_M10-Pad2_ Net-_M10-Pad3_ Net-_M10-Pad1_ mosfet_p
M11  Net-_M10-Pad3_ Net-_M11-Pad2_ Net-_M11-Pad3_ Net-_M10-Pad1_ mosfet_p
M9  Net-_M11-Pad3_ Net-_M10-Pad2_ GND GND mosfet_n
M12  Net-_M11-Pad3_ Net-_M11-Pad2_ GND GND mosfet_n
M13  Net-_M10-Pad1_ Net-_M13-Pad2_ Net-_M13-Pad3_ Net-_M10-Pad1_ mosfet_p
M16  Net-_M10-Pad1_ Net-_M14-Pad2_ Net-_M13-Pad3_ Net-_M10-Pad1_ mosfet_p
M14  Net-_M13-Pad3_ Net-_M14-Pad2_ Net-_M14-Pad3_ GND mosfet_n
M15  Net-_M14-Pad3_ Net-_M13-Pad2_ GND GND mosfet_n
M5  Net-_M5-Pad1_ Net-_M5-Pad2_ GND GND mosfet_n
M6  Net-_M10-Pad1_ Net-_M5-Pad2_ Net-_M5-Pad1_ Net-_M10-Pad1_ mosfet_p
M3  Net-_M3-Pad1_ Net-_M3-Pad2_ GND GND mosfet_n
M4  Net-_M10-Pad1_ Net-_M3-Pad2_ Net-_M3-Pad1_ Net-_M10-Pad1_ mosfet_p
M1  Net-_M1-Pad1_ Net-_M1-Pad2_ GND GND mosfet_n
M2  Net-_M10-Pad1_ Net-_M1-Pad2_ Net-_M1-Pad1_ Net-_M10-Pad1_ mosfet_p

.end
