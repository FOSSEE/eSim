.title KiCad schematic
U3 Net-_Q22-Pad3_ Net-_D2-Pad1_ Net-_Q12-Pad1_ Net-_Q17-Pad1_ Net-_Q16-Pad3_ Net-_Q18-Pad2_ Net-_R13-Pad1_ Net-_Q14-Pad2_ Net-_Q10-Pad1_ Net-_Q2-Pad3_ PORT
R2 Net-_Q2-Pad3_ Net-_D2-Pad2_ 5.0k
Q2 Net-_D1-Pad2_ Net-_D2-Pad2_ Net-_Q2-Pad3_ eSim_NPN
U1 Net-_Q2-Pad3_ Net-_D1-Pad1_ zener
D2 Net-_D2-Pad1_ Net-_D2-Pad2_ eSim_Diode
R8 Net-_Q2-Pad3_ Net-_D4-Pad2_ 700
D4 Net-_D3-Pad2_ Net-_D4-Pad2_ eSim_Diode
Q5 Net-_Q10-Pad1_ Net-_D3-Pad1_ Net-_Q11-Pad2_ eSim_NPN
D3 Net-_D3-Pad1_ Net-_D3-Pad2_ eSim_Diode
U2 Net-_Q2-Pad3_ Net-_D1-Pad2_ zener
R7 Net-_D3-Pad1_ Net-_Q9-Pad2_ 2.67k
R10 Net-_Q7-Pad1_ Net-_Q6-Pad3_ 3.2k
Q6 Net-_Q6-Pad1_ Net-_Q15-Pad2_ Net-_Q6-Pad3_ eSim_NPN
R5 Net-_Q15-Pad2_ Net-_Q12-Pad1_ 834
Q4 Net-_Q15-Pad2_ Net-_D1-Pad2_ Net-_Q4-Pad3_ eSim_NPN
R6 Net-_Q9-Pad2_ Net-_Q4-Pad3_ 4.63k
Q19 Net-_Q18-Pad3_ Net-_Q11-Pad2_ Net-_Q19-Pad3_ eSim_NPN
R17 Net-_Q2-Pad3_ Net-_Q19-Pad3_ 410
Q21 Net-_Q17-Pad1_ Net-_Q16-Pad3_ Net-_Q18-Pad3_ eSim_NPN
Q18 Net-_Q18-Pad1_ Net-_Q18-Pad2_ Net-_Q18-Pad3_ eSim_NPN
Q13 Net-_D5-Pad2_ Net-_Q13-Pad2_ Net-_Q10-Pad3_ eSim_NPN
Q14 Net-_D5-Pad2_ Net-_Q14-Pad2_ Net-_Q13-Pad2_ eSim_NPN
R1 Net-_D1-Pad1_ Net-_Q12-Pad1_ 60k
D1 Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
Q1 Net-_D1-Pad2_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_PNP
R4 Net-_Q7-Pad1_ Net-_Q1-Pad2_ 1.6k
Q3 Net-_Q1-Pad3_ Net-_Q15-Pad2_ Net-_Q1-Pad2_ eSim_NPN
R3 Net-_Q1-Pad3_ Net-_Q12-Pad1_ 514
Q12 Net-_Q12-Pad1_ Net-_D5-Pad1_ Net-_Q10-Pad1_ eSim_NPN
D5 Net-_D5-Pad1_ Net-_D5-Pad2_ eSim_Diode
Q15 Net-_Q15-Pad1_ Net-_Q15-Pad2_ Net-_Q15-Pad3_ eSim_NPN
R14 Net-_Q7-Pad1_ Net-_Q15-Pad3_ 1.6k
R13 Net-_R13-Pad1_ Net-_D5-Pad2_ 50
Q16 Net-_D5-Pad1_ Net-_Q16-Pad2_ Net-_Q16-Pad3_ eSim_NPN
R15 Net-_Q18-Pad2_ Net-_Q16-Pad2_ 1.0k
Q17 Net-_Q17-Pad1_ Net-_Q15-Pad3_ Net-_Q15-Pad1_ eSim_PNP
R16 Net-_Q15-Pad1_ Net-_Q12-Pad1_ 514
Q8 Net-_D5-Pad1_ Net-_Q6-Pad3_ Net-_Q6-Pad1_ eSim_PNP
R11 Net-_Q6-Pad1_ Net-_Q12-Pad1_ 1.03k
Q9 Net-_Q10-Pad1_ Net-_Q9-Pad2_ Net-_Q10-Pad2_ eSim_NPN
Q10 Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
Q7 Net-_Q7-Pad1_ Net-_Q11-Pad2_ Net-_Q7-Pad3_ eSim_NPN
R12 Net-_Q2-Pad3_ Net-_Q11-Pad3_ 834
Q11 Net-_Q10-Pad3_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_NPN
R9 Net-_Q2-Pad3_ Net-_Q7-Pad3_ 623
Q22 Net-_Q12-Pad1_ Net-_Q18-Pad1_ Net-_Q22-Pad3_ eSim_NPN
Q20 Net-_Q12-Pad1_ Net-_Q17-Pad1_ Net-_Q18-Pad1_ eSim_NPN
.end
