* C:\FOSSEE\eSim\library\SubcircuitLibrary\CD4032B\CD4032B.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/17/25 16:06:31

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U4  Net-_U1-Pad1_ Net-_U14-Pad1_ d_inverter
U14  Net-_U14-Pad1_ Net-_U14-Pad2_ d_inverter
U5  Net-_U1-Pad2_ Net-_U16-Pad1_ d_inverter
U16  Net-_U16-Pad1_ Net-_U16-Pad2_ d_inverter
U26  Net-_U14-Pad2_ Net-_U16-Pad2_ Net-_U26-Pad3_ d_xor
U42  Net-_U26-Pad3_ Net-_U42-Pad2_ Net-_U42-Pad3_ d_xnor
U48  Net-_U42-Pad3_ Net-_U48-Pad2_ d_inverter
U52  Net-_U48-Pad2_ Net-_U52-Pad2_ d_buffer
U55  Net-_U52-Pad2_ Net-_U55-Pad2_ d_inverter
U58  Net-_U55-Pad2_ Net-_U58-Pad2_ d_inverter
U63  Net-_U58-Pad2_ Net-_U1-Pad4_ d_buffer
U29  Net-_U29-Pad1_ Net-_U14-Pad2_ Net-_U29-Pad3_ d_and
U30  Net-_U14-Pad2_ Net-_U16-Pad2_ Net-_U30-Pad3_ d_and
U31  Net-_U16-Pad2_ Net-_U29-Pad1_ Net-_U31-Pad3_ d_and
X1  Net-_U29-Pad3_ Net-_U30-Pad3_ Net-_U31-Pad3_ VDD VSS Net-_U45-Pad1_ 3_nor_gate
U61  Net-_U29-Pad1_ Net-_U35-Pad2_ Net-_U42-Pad2_ d_xor
U12  Net-_U1-Pad3_ Net-_U12-Pad2_ d_inverter
U21  Net-_U12-Pad2_ Net-_U21-Pad2_ d_inverter
U35  Net-_U21-Pad2_ Net-_U35-Pad2_ d_buffer
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ VSS VDD PORT
U6  Net-_U1-Pad5_ Net-_U17-Pad1_ d_inverter
U17  Net-_U17-Pad1_ Net-_U17-Pad2_ d_inverter
U7  Net-_U1-Pad6_ Net-_U18-Pad1_ d_inverter
U18  Net-_U18-Pad1_ Net-_U18-Pad2_ d_inverter
U27  Net-_U17-Pad2_ Net-_U18-Pad2_ Net-_U27-Pad3_ d_xor
U43  Net-_U27-Pad3_ Net-_U43-Pad2_ Net-_U43-Pad3_ d_xnor
U49  Net-_U43-Pad3_ Net-_U49-Pad2_ d_inverter
U53  Net-_U49-Pad2_ Net-_U53-Pad2_ d_buffer
U56  Net-_U53-Pad2_ Net-_U56-Pad2_ d_inverter
U59  Net-_U56-Pad2_ Net-_U59-Pad2_ d_inverter
U65  Net-_U59-Pad2_ Net-_U1-Pad8_ d_buffer
U32  Net-_U32-Pad1_ Net-_U17-Pad2_ Net-_U32-Pad3_ d_and
U33  Net-_U17-Pad2_ Net-_U18-Pad2_ Net-_U33-Pad3_ d_and
U34  Net-_U18-Pad2_ Net-_U32-Pad1_ Net-_U34-Pad3_ d_and
X2  Net-_U32-Pad3_ Net-_U33-Pad3_ Net-_U34-Pad3_ VDD VSS Net-_U47-Pad1_ 3_nor_gate
U62  Net-_U32-Pad1_ Net-_U40-Pad2_ Net-_U43-Pad2_ d_xor
U13  Net-_U1-Pad7_ Net-_U13-Pad2_ d_inverter
U23  Net-_U13-Pad2_ Net-_U23-Pad2_ d_inverter
U40  Net-_U23-Pad2_ Net-_U40-Pad2_ d_buffer
U8  Net-_U1-Pad9_ Net-_U19-Pad1_ d_inverter
U19  Net-_U19-Pad1_ Net-_U19-Pad2_ d_inverter
U9  Net-_U1-Pad10_ Net-_U20-Pad1_ d_inverter
U20  Net-_U20-Pad1_ Net-_U20-Pad2_ d_inverter
U28  Net-_U19-Pad2_ Net-_U20-Pad2_ Net-_U28-Pad3_ d_xor
U44  Net-_U28-Pad3_ Net-_U44-Pad2_ Net-_U44-Pad3_ d_xnor
U50  Net-_U44-Pad3_ Net-_U50-Pad2_ d_inverter
U54  Net-_U50-Pad2_ Net-_U54-Pad2_ d_buffer
U57  Net-_U54-Pad2_ Net-_U57-Pad2_ d_inverter
U60  Net-_U57-Pad2_ Net-_U60-Pad2_ d_inverter
U66  Net-_U60-Pad2_ Net-_U1-Pad12_ d_buffer
U36  Net-_U36-Pad1_ Net-_U19-Pad2_ Net-_U36-Pad3_ d_and
U37  Net-_U19-Pad2_ Net-_U20-Pad2_ Net-_U37-Pad3_ d_and
U38  Net-_U20-Pad2_ Net-_U36-Pad1_ Net-_U38-Pad3_ d_and
X3  Net-_U36-Pad3_ Net-_U37-Pad3_ Net-_U38-Pad3_ VDD VSS Net-_U46-Pad1_ 3_nor_gate
U64  Net-_U36-Pad1_ Net-_U41-Pad2_ Net-_U44-Pad2_ d_xor
U15  Net-_U1-Pad11_ Net-_U15-Pad2_ d_inverter
U25  Net-_U15-Pad2_ Net-_U25-Pad2_ d_inverter
U41  Net-_U25-Pad2_ Net-_U41-Pad2_ d_buffer
U2  Net-_U1-Pad13_ Net-_U10-Pad1_ d_inverter
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ d_inverter
U22  Net-_U10-Pad2_ Net-_U22-Pad2_ d_buffer
U51  Net-_U3-Pad3_ Net-_U24-Pad2_ Net-_U45-Pad3_ d_nand
U11  Net-_U1-Pad14_ Net-_U11-Pad2_ d_inverter
U24  Net-_U11-Pad2_ Net-_U24-Pad2_ d_inverter
U39  Net-_U24-Pad2_ Net-_U39-Pad2_ d_buffer
U3  Net-_U22-Pad2_ Net-_U24-Pad2_ Net-_U3-Pad3_ qb_dff
U45  Net-_U45-Pad1_ Net-_U39-Pad2_ Net-_U45-Pad3_ Net-_U29-Pad1_ s_dff
U47  Net-_U47-Pad1_ Net-_U39-Pad2_ Net-_U45-Pad3_ Net-_U32-Pad1_ s_dff
U46  Net-_U46-Pad1_ Net-_U39-Pad2_ Net-_U45-Pad3_ Net-_U36-Pad1_ s_dff

.end
