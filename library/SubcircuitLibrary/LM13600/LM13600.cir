* C:\FOSSEE\eSim\library\SubcircuitLibrary\LM13600\LM13600.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 04/26/25 18:13:20

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
Q2  Net-_Q2-Pad1_ Net-_D2-Pad1_ Net-_D2-Pad2_ eSim_NPN
Q7  Net-_Q12-Pad3_ Net-_D2-Pad1_ Net-_D2-Pad2_ eSim_NPN
Q4  Net-_Q1-Pad3_ Net-_Q2-Pad1_ Net-_D2-Pad1_ eSim_NPN
D2  Net-_D2-Pad1_ Net-_D2-Pad2_ eSim_Diode
Q1  Net-_Q1-Pad1_ Net-_D1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
Q6  Net-_Q10-Pad2_ Net-_D4-Pad2_ Net-_Q1-Pad3_ eSim_NPN
D1  Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
D4  Net-_D1-Pad1_ Net-_D4-Pad2_ eSim_Diode
Q3  Net-_Q1-Pad1_ Net-_D3-Pad2_ Net-_D3-Pad1_ eSim_PNP
Q5  Net-_Q11-Pad2_ Net-_Q1-Pad1_ Net-_D3-Pad2_ eSim_PNP
D3  Net-_D3-Pad1_ Net-_D3-Pad2_ eSim_Diode
Q8  Net-_Q10-Pad2_ Net-_D5-Pad2_ Net-_D3-Pad1_ eSim_PNP
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_D5-Pad2_ eSim_PNP
D5  Net-_D3-Pad1_ Net-_D5-Pad2_ eSim_Diode
Q11  Net-_Q10-Pad1_ Net-_Q11-Pad2_ Net-_D6-Pad1_ eSim_NPN
Q9  Net-_Q11-Pad2_ Net-_D6-Pad1_ Net-_D2-Pad2_ eSim_NPN
D6  Net-_D6-Pad1_ Net-_D2-Pad2_ eSim_Diode
Q12  Net-_D3-Pad1_ Net-_Q12-Pad2_ Net-_Q12-Pad3_ eSim_NPN
Q13  Net-_D3-Pad1_ Net-_Q12-Pad3_ Net-_Q13-Pad3_ eSim_NPN
U1  Net-_D1-Pad1_ Net-_D1-Pad1_ Net-_D1-Pad2_ Net-_D1-Pad2_ Net-_Q2-Pad1_ Net-_Q2-Pad1_ Net-_D2-Pad2_ Net-_D3-Pad1_ Net-_D4-Pad2_ Net-_D4-Pad2_ Net-_Q12-Pad2_ Net-_Q10-Pad1_ Net-_Q10-Pad1_ Net-_Q12-Pad2_ Net-_Q13-Pad3_ Net-_Q13-Pad3_ PORT

.end
