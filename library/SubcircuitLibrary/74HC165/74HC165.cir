.title KiCad schematic
U1 Net-_U1-Pad1_ Net-_U1-Pad2_ d_inverter
U4 Net-_U2-Pad15_ Net-_U3-Pad2_ d_inverter
U8 Net-_U3-Pad3_ Net-_U8-Pad2_ Net-_U5-Pad1_ d_nand
U5 Net-_U5-Pad1_ Net-_U5-Pad1_ Net-_U13-Pad2_ d_nand
U9 Net-_U10-Pad2_ Net-_U8-Pad2_ d_inverter
U3 Net-_U1-Pad2_ Net-_U3-Pad2_ Net-_U3-Pad3_ d_nand
U10 Net-_U10-Pad1_ Net-_U10-Pad2_ d_inverter
U2 Net-_U10-Pad1_ Net-_U1-Pad1_ Net-_U2-Pad3_ Net-_U2-Pad4_ Net-_U2-Pad5_ Net-_U2-Pad6_ Net-_U2-Pad7_ unconnected-_U2-Pad8_ Net-_U2-Pad9_ Net-_U2-Pad10_ Net-_U11-Pad1_ Net-_U17-Pad1_ Net-_U2-Pad13_ Net-_U2-Pad14_ Net-_U2-Pad15_ unconnected-_U2-Pad16_ PORT
U16 Net-_U13-Pad5_ plot_v1
U14 Net-_U14-Pad1_ Net-_U13-Pad4_ d_inverter
U15 Net-_U10-Pad2_ Net-_U11-Pad3_ Net-_U14-Pad1_ d_nand
U11 Net-_U11-Pad1_ Net-_U10-Pad2_ Net-_U11-Pad3_ d_nand
U13 Net-_U13-Pad1_ Net-_U13-Pad2_ Net-_U12-Pad2_ Net-_U13-Pad4_ Net-_U13-Pad5_ unconnected-_U13-Pad6_ d_dff
U12 Net-_U11-Pad3_ Net-_U12-Pad2_ d_inverter
U22 Net-_U2-Pad13_ Net-_U10-Pad2_ Net-_U22-Pad3_ d_nand
U17 Net-_U17-Pad1_ Net-_U10-Pad2_ Net-_U17-Pad3_ d_nand
U24 Net-_U19-Pad5_ Net-_U13-Pad2_ Net-_U23-Pad2_ Net-_U24-Pad4_ Net-_U24-Pad5_ unconnected-_U24-Pad6_ d_dff
U26 Net-_U10-Pad2_ Net-_U22-Pad3_ Net-_U25-Pad1_ d_nand
U25 Net-_U25-Pad1_ Net-_U24-Pad4_ d_inverter
U21 Net-_U10-Pad2_ Net-_U17-Pad3_ Net-_U20-Pad1_ d_nand
U20 Net-_U20-Pad1_ Net-_U19-Pad4_ d_inverter
U19 Net-_U13-Pad5_ Net-_U13-Pad2_ Net-_U18-Pad2_ Net-_U19-Pad4_ Net-_U19-Pad5_ unconnected-_U19-Pad6_ d_dff
U23 Net-_U22-Pad3_ Net-_U23-Pad2_ d_inverter
U18 Net-_U17-Pad3_ Net-_U18-Pad2_ d_inverter
U7 Net-_U6-Pad2_ Net-_U13-Pad1_ d_inverter
U6 Net-_U2-Pad10_ Net-_U6-Pad2_ d_inverter
U35 Net-_U35-Pad1_ Net-_U34-Pad4_ d_inverter
U36 Net-_U10-Pad2_ Net-_U32-Pad3_ Net-_U35-Pad1_ d_nand
U29 Net-_U24-Pad5_ Net-_U13-Pad2_ Net-_U28-Pad2_ Net-_U29-Pad4_ Net-_U29-Pad5_ unconnected-_U29-Pad6_ d_dff
U28 Net-_U27-Pad3_ Net-_U28-Pad2_ d_inverter
U30 Net-_U30-Pad1_ Net-_U29-Pad4_ d_inverter
U31 Net-_U10-Pad2_ Net-_U27-Pad3_ Net-_U30-Pad1_ d_nand
U34 Net-_U29-Pad5_ Net-_U13-Pad2_ Net-_U33-Pad2_ Net-_U34-Pad4_ Net-_U34-Pad5_ unconnected-_U34-Pad6_ d_dff
U33 Net-_U32-Pad3_ Net-_U33-Pad2_ d_inverter
U37 Net-_U2-Pad4_ Net-_U10-Pad2_ Net-_U37-Pad3_ d_nand
U27 Net-_U2-Pad14_ Net-_U10-Pad2_ Net-_U27-Pad3_ d_nand
U32 Net-_U2-Pad3_ Net-_U10-Pad2_ Net-_U32-Pad3_ d_nand
U47 Net-_U2-Pad6_ Net-_U10-Pad2_ Net-_U47-Pad3_ d_nand
U42 Net-_U2-Pad5_ Net-_U10-Pad2_ Net-_U42-Pad3_ d_nand
U50 Net-_U50-Pad1_ Net-_U49-Pad4_ d_inverter
U51 Net-_U10-Pad2_ Net-_U47-Pad3_ Net-_U50-Pad1_ d_nand
U48 Net-_U47-Pad3_ Net-_U48-Pad2_ d_inverter
U49 Net-_U44-Pad5_ Net-_U13-Pad2_ Net-_U48-Pad2_ Net-_U49-Pad4_ Net-_U2-Pad9_ Net-_U2-Pad7_ d_dff
U45 Net-_U45-Pad1_ Net-_U44-Pad4_ d_inverter
U44 Net-_U39-Pad5_ Net-_U13-Pad2_ Net-_U43-Pad2_ Net-_U44-Pad4_ Net-_U44-Pad5_ unconnected-_U44-Pad6_ d_dff
U43 Net-_U42-Pad3_ Net-_U43-Pad2_ d_inverter
U46 Net-_U10-Pad2_ Net-_U42-Pad3_ Net-_U45-Pad1_ d_nand
U41 Net-_U10-Pad2_ Net-_U37-Pad3_ Net-_U40-Pad1_ d_nand
U40 Net-_U40-Pad1_ Net-_U39-Pad4_ d_inverter
U39 Net-_U34-Pad5_ Net-_U13-Pad2_ Net-_U38-Pad2_ Net-_U39-Pad4_ Net-_U39-Pad5_ unconnected-_U39-Pad6_ d_dff
U38 Net-_U37-Pad3_ Net-_U38-Pad2_ d_inverter
.end
