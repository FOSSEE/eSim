* C:\FOSSEE\eSim\library\SubcircuitLibrary\PI3B16244\PI3B16244.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 01/30/26 19:37:26

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U1  1BE_B Net-_U1-Pad2_ adc_bridge_1
U5  Net-_U1-Pad2_ Net-_U5-Pad2_ d_inverter
M1  Net-_M1-Pad1_ 1BE_B Net-_M1-Pad3_ GND eSim_MOS_N
M5  Net-_M1-Pad1_ Net-_M5-Pad2_ Net-_M1-Pad3_ VDD eSim_MOS_P
U9  Net-_U5-Pad2_ Net-_M5-Pad2_ dac_bridge_1
U2  1BE_B Net-_U2-Pad2_ adc_bridge_1
U6  Net-_U2-Pad2_ Net-_U10-Pad1_ d_inverter
M2  Net-_M2-Pad1_ 1BE_B Net-_M2-Pad3_ GND eSim_MOS_N
M6  Net-_M2-Pad1_ Net-_M6-Pad2_ Net-_M2-Pad3_ VDD eSim_MOS_P
U10  Net-_U10-Pad1_ Net-_M6-Pad2_ dac_bridge_1
U3  1BE_B Net-_U3-Pad2_ adc_bridge_1
U7  Net-_U3-Pad2_ Net-_U11-Pad1_ d_inverter
M3  Net-_M3-Pad1_ 1BE_B Net-_M3-Pad3_ GND eSim_MOS_N
M7  Net-_M3-Pad1_ Net-_M7-Pad2_ Net-_M3-Pad3_ VDD eSim_MOS_P
U11  Net-_U11-Pad1_ Net-_M7-Pad2_ dac_bridge_1
U4  1BE_B Net-_U4-Pad2_ adc_bridge_1
U8  Net-_U4-Pad2_ Net-_U12-Pad1_ d_inverter
M4  Net-_M4-Pad1_ 1BE_B Net-_M4-Pad3_ GND eSim_MOS_N
M8  Net-_M4-Pad1_ Net-_M8-Pad2_ Net-_M4-Pad3_ VDD eSim_MOS_P
U12  Net-_U12-Pad1_ Net-_M8-Pad2_ dac_bridge_1
U26  3BE_B Net-_U26-Pad2_ adc_bridge_1
U30  Net-_U26-Pad2_ Net-_U30-Pad2_ d_inverter
M17  Net-_M17-Pad1_ 3BE_B Net-_M17-Pad3_ GND eSim_MOS_N
M21  Net-_M17-Pad1_ Net-_M21-Pad2_ Net-_M17-Pad3_ VDD eSim_MOS_P
U34  Net-_U30-Pad2_ Net-_M21-Pad2_ dac_bridge_1
U27  3BE_B Net-_U27-Pad2_ adc_bridge_1
U31  Net-_U27-Pad2_ Net-_U31-Pad2_ d_inverter
M18  Net-_M18-Pad1_ 3BE_B Net-_M18-Pad3_ GND eSim_MOS_N
M22  Net-_M18-Pad1_ Net-_M22-Pad2_ Net-_M18-Pad3_ VDD eSim_MOS_P
U35  Net-_U31-Pad2_ Net-_M22-Pad2_ dac_bridge_1
U28  3BE_B Net-_U28-Pad2_ adc_bridge_1
U32  Net-_U28-Pad2_ Net-_U32-Pad2_ d_inverter
M19  Net-_M19-Pad1_ 3BE_B Net-_M19-Pad3_ GND eSim_MOS_N
M23  Net-_M19-Pad1_ Net-_M23-Pad2_ Net-_M19-Pad3_ VDD eSim_MOS_P
U36  Net-_U32-Pad2_ Net-_M23-Pad2_ dac_bridge_1
U29  3BE_B Net-_U29-Pad2_ adc_bridge_1
U33  Net-_U29-Pad2_ Net-_U33-Pad2_ d_inverter
M20  Net-_M20-Pad1_ 3BE_B Net-_M20-Pad3_ GND eSim_MOS_N
M24  Net-_M20-Pad1_ Net-_M24-Pad2_ Net-_M20-Pad3_ VDD eSim_MOS_P
U37  Net-_U33-Pad2_ Net-_M24-Pad2_ dac_bridge_1
U14  2BE_B Net-_U14-Pad2_ adc_bridge_1
U18  Net-_U14-Pad2_ Net-_U18-Pad2_ d_inverter
M9  Net-_M13-Pad1_ 2BE_B Net-_M13-Pad3_ GND eSim_MOS_N
M13  Net-_M13-Pad1_ Net-_M13-Pad2_ Net-_M13-Pad3_ VDD eSim_MOS_P
U22  Net-_U18-Pad2_ Net-_M13-Pad2_ dac_bridge_1
U15  2BE_B Net-_U15-Pad2_ adc_bridge_1
U19  Net-_U15-Pad2_ Net-_U19-Pad2_ d_inverter
M10  Net-_M10-Pad1_ 2BE_B Net-_M10-Pad3_ GND eSim_MOS_N
M14  Net-_M10-Pad1_ Net-_M14-Pad2_ Net-_M10-Pad3_ VDD eSim_MOS_P
U23  Net-_U19-Pad2_ Net-_M14-Pad2_ dac_bridge_1
U16  2BE_B Net-_U16-Pad2_ adc_bridge_1
U20  Net-_U16-Pad2_ Net-_U20-Pad2_ d_inverter
M11  Net-_M11-Pad1_ 2BE_B Net-_M11-Pad3_ GND eSim_MOS_N
M15  Net-_M11-Pad1_ Net-_M15-Pad2_ Net-_M11-Pad3_ VDD eSim_MOS_P
U24  Net-_U20-Pad2_ Net-_M15-Pad2_ dac_bridge_1
U17  2BE_B Net-_U17-Pad2_ adc_bridge_1
U21  Net-_U17-Pad2_ Net-_U21-Pad2_ d_inverter
M12  Net-_M12-Pad1_ 2BE_B Net-_M12-Pad3_ GND eSim_MOS_N
M16  Net-_M12-Pad1_ Net-_M16-Pad2_ Net-_M12-Pad3_ VDD eSim_MOS_P
U25  Net-_U21-Pad2_ Net-_M16-Pad2_ dac_bridge_1
U39  4BE_B Net-_U39-Pad2_ adc_bridge_1
U44  Net-_U39-Pad2_ Net-_U44-Pad2_ d_inverter
M25  Net-_M25-Pad1_ 4BE_B Net-_M25-Pad3_ GND eSim_MOS_N
M29  Net-_M25-Pad1_ Net-_M29-Pad2_ Net-_M25-Pad3_ VDD eSim_MOS_P
U48  Net-_U44-Pad2_ Net-_M29-Pad2_ dac_bridge_1
U40  4BE_B Net-_U40-Pad2_ adc_bridge_1
U45  Net-_U40-Pad2_ Net-_U45-Pad2_ d_inverter
M26  Net-_M26-Pad1_ 4BE_B Net-_M26-Pad3_ GND eSim_MOS_N
M30  Net-_M26-Pad1_ Net-_M30-Pad2_ Net-_M26-Pad3_ VDD eSim_MOS_P
U49  Net-_U45-Pad2_ Net-_M30-Pad2_ dac_bridge_1
U41  4BE_B Net-_U41-Pad2_ adc_bridge_1
U46  Net-_U41-Pad2_ Net-_U46-Pad2_ d_inverter
M27  Net-_M27-Pad1_ 4BE_B Net-_M27-Pad3_ GND eSim_MOS_N
M31  Net-_M27-Pad1_ Net-_M31-Pad2_ Net-_M27-Pad3_ VDD eSim_MOS_P
U50  Net-_U46-Pad2_ Net-_M31-Pad2_ dac_bridge_1
U42  4BE_B Net-_U42-Pad2_ adc_bridge_1
U47  Net-_U42-Pad2_ Net-_U47-Pad2_ d_inverter
M28  Net-_M28-Pad1_ 4BE_B Net-_M28-Pad3_ GND eSim_MOS_N
M32  Net-_M28-Pad1_ Net-_M32-Pad2_ Net-_M28-Pad3_ VDD eSim_MOS_P
U51  Net-_U47-Pad2_ Net-_M32-Pad2_ dac_bridge_1
U13  Net-_M1-Pad1_ Net-_M2-Pad1_ Net-_M3-Pad1_ Net-_M4-Pad1_ Net-_M1-Pad3_ Net-_M2-Pad3_ Net-_M3-Pad3_ Net-_M4-Pad3_ 4BE_B VDD 3BE_B 2BE_B Net-_M13-Pad1_ Net-_M10-Pad1_ Net-_M11-Pad1_ Net-_M12-Pad1_ Net-_M13-Pad3_ Net-_M10-Pad3_ Net-_M11-Pad3_ Net-_M12-Pad3_ 1BE_B GND Net-_M17-Pad1_ Net-_M18-Pad1_ Net-_M19-Pad1_ Net-_M20-Pad1_ PORT
U38  Net-_M17-Pad3_ Net-_M18-Pad3_ Net-_M19-Pad3_ Net-_M20-Pad3_ Net-_M25-Pad1_ Net-_M26-Pad1_ Net-_M27-Pad1_ Net-_M28-Pad1_ Net-_M25-Pad3_ Net-_M26-Pad3_ Net-_M27-Pad3_ Net-_M28-Pad3_ PORT

.end
