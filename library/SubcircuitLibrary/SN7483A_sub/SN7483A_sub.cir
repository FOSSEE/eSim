* C:\FOSSEE\eSim\library\SubcircuitLibrary\SN7483A_sub\SN7483A_sub.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 13/06/2024 2:46:07 PM

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U23  Net-_U12-Pad3_ Net-_U23-Pad2_ d_buffer
U24  Net-_U15-Pad1_ Net-_U11-Pad3_ Net-_U24-Pad3_ d_and
X1  Net-_U13-Pad1_ Net-_U11-Pad3_ Net-_U21-Pad1_ Net-_X1-Pad4_ 3_and
X2  Net-_U14-Pad1_ Net-_U11-Pad3_ Net-_U21-Pad1_ Net-_U17-Pad1_ Net-_X2-Pad5_ 4_and
X4  Net-_U11-Pad3_ Net-_U21-Pad1_ Net-_U17-Pad1_ Net-_U19-Pad1_ Net-_U10-Pad2_ Net-_U36-Pad2_ 5_and
X8  Net-_U23-Pad2_ Net-_U24-Pad3_ Net-_X1-Pad4_ Net-_X2-Pad5_ Net-_U36-Pad1_ 4_OR
U36  Net-_U36-Pad1_ Net-_U36-Pad2_ Net-_U36-Pad3_ d_or
U40  Net-_U36-Pad3_ Net-_U40-Pad2_ d_inverter
U26  Net-_U11-Pad3_ Net-_U16-Pad2_ Net-_U26-Pad3_ d_and
U16  Net-_U12-Pad3_ Net-_U16-Pad2_ d_inverter
U27  Net-_U15-Pad1_ Net-_U27-Pad2_ d_buffer
U29  Net-_U13-Pad1_ Net-_U21-Pad1_ Net-_U29-Pad3_ d_and
X5  Net-_U14-Pad1_ Net-_U21-Pad1_ Net-_U17-Pad1_ Net-_X5-Pad4_ 3_and
X6  Net-_U21-Pad1_ Net-_U17-Pad1_ Net-_U19-Pad1_ Net-_U10-Pad2_ Net-_X6-Pad5_ 4_and
X7  Net-_U27-Pad2_ Net-_U29-Pad3_ Net-_X5-Pad4_ Net-_X6-Pad5_ Net-_U35-Pad1_ 4_OR
U35  Net-_U35-Pad1_ Net-_U35-Pad2_ d_inverter
U39  Net-_U26-Pad3_ Net-_U35-Pad2_ Net-_U39-Pad3_ d_xor
U21  Net-_U21-Pad1_ Net-_U15-Pad2_ Net-_U21-Pad3_ d_and
U15  Net-_U15-Pad1_ Net-_U15-Pad2_ d_inverter
U22  Net-_U13-Pad1_ Net-_U22-Pad2_ d_buffer
U28  Net-_U14-Pad1_ Net-_U17-Pad1_ Net-_U28-Pad3_ d_and
X3  Net-_U17-Pad1_ Net-_U19-Pad1_ Net-_U10-Pad2_ Net-_U33-Pad2_ 3_and
U30  Net-_U22-Pad2_ Net-_U28-Pad3_ Net-_U30-Pad3_ d_or
U33  Net-_U30-Pad3_ Net-_U33-Pad2_ Net-_U33-Pad3_ d_or
U41  Net-_U21-Pad3_ Net-_U37-Pad2_ Net-_U41-Pad3_ d_xor
U17  Net-_U17-Pad1_ Net-_U13-Pad2_ Net-_U17-Pad3_ d_and
U13  Net-_U13-Pad1_ Net-_U13-Pad2_ d_inverter
U18  Net-_U14-Pad1_ Net-_U18-Pad2_ d_buffer
U25  Net-_U19-Pad1_ Net-_U10-Pad2_ Net-_U25-Pad3_ d_and
U19  Net-_U19-Pad1_ Net-_U14-Pad2_ Net-_U19-Pad3_ d_and
U14  Net-_U14-Pad1_ Net-_U14-Pad2_ d_inverter
U34  Net-_U31-Pad3_ Net-_U34-Pad2_ d_inverter
U38  Net-_U17-Pad3_ Net-_U34-Pad2_ Net-_U38-Pad3_ d_xor
U32  Net-_U19-Pad3_ Net-_U20-Pad2_ Net-_U32-Pad3_ d_xor
U31  Net-_U18-Pad2_ Net-_U25-Pad3_ Net-_U31-Pad3_ d_or
U20  Net-_U10-Pad2_ Net-_U20-Pad2_ d_inverter
U37  Net-_U33-Pad3_ Net-_U37-Pad2_ d_inverter
U11  Net-_U11-Pad1_ Net-_U11-Pad2_ Net-_U11-Pad3_ d_nand
U12  Net-_U11-Pad1_ Net-_U11-Pad2_ Net-_U12-Pad3_ d_nor
U8  Net-_U2-Pad11_ Net-_U2-Pad12_ Net-_U21-Pad1_ d_nand
U9  Net-_U2-Pad11_ Net-_U2-Pad12_ Net-_U15-Pad1_ d_nor
U4  Net-_U2-Pad13_ Net-_U2-Pad14_ Net-_U17-Pad1_ d_nand
U5  Net-_U2-Pad13_ Net-_U2-Pad14_ Net-_U13-Pad1_ d_nor
U6  Net-_U2-Pad15_ Net-_U2-Pad16_ Net-_U19-Pad1_ d_nand
U7  Net-_U2-Pad15_ Net-_U2-Pad16_ Net-_U14-Pad1_ d_nor
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ d_inverter
U2  Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad8_ Net-_U1-Pad14_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad6_ Net-_U1-Pad5_ Net-_U11-Pad1_ Net-_U11-Pad2_ Net-_U2-Pad11_ Net-_U2-Pad12_ Net-_U2-Pad13_ Net-_U2-Pad14_ Net-_U2-Pad15_ Net-_U2-Pad16_ adc_bridge_8
U3  Net-_U1-Pad7_ Net-_U10-Pad1_ adc_bridge_1
U42  Net-_U40-Pad2_ Net-_U39-Pad3_ Net-_U41-Pad3_ Net-_U38-Pad3_ Net-_U32-Pad3_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad13_ Net-_U1-Pad1_ Net-_U1-Pad4_ dac_bridge_5
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ PORT

.end
