* C:\FOSSEE\eSim\library\SubcircuitLibrary\CD4529BM\CD4529BM.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/16/25 15:55:07

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U2  Net-_U1-Pad2_ Net-_U2-Pad2_ d_inverter
U4  Net-_U1-Pad1_ Net-_U4-Pad2_ d_inverter
U6  Net-_U1-Pad3_ Net-_U6-Pad2_ d_inverter
U8  Net-_U1-Pad4_ Net-_U8-Pad2_ d_inverter
U3  Net-_U2-Pad2_ Net-_U3-Pad2_ d_inverter
U5  Net-_U4-Pad2_ Net-_U5-Pad2_ d_inverter
U7  Net-_U6-Pad2_ Net-_U7-Pad2_ d_inverter
U9  Net-_U8-Pad2_ Net-_U9-Pad2_ d_inverter
U25  Net-_U14-Pad2_ Net-_U25-Pad2_ d_inverter
M16  Net-_M1-Pad3_ Net-_M16-Pad2_ Net-_M12-Pad1_ VDD mosfet_p
M12  Net-_M12-Pad1_ Net-_M12-Pad2_ Net-_M1-Pad3_ GND mosfet_n
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_M13-Pad3_ Net-_M14-Pad3_ Net-_M11-Pad3_ Net-_M10-Pad3_ Net-_M15-Pad3_ Net-_M2-Pad1_ Net-_M1-Pad1_ Net-_M12-Pad1_ Net-_M1-Pad3_ Net-_M10-Pad1_ VDD GND PORT
U18  Net-_U11-Pad2_ Net-_U18-Pad2_ d_inverter
M6  Net-_M1-Pad3_ Net-_M6-Pad2_ Net-_M1-Pad1_ VDD mosfet_p
M1  Net-_M1-Pad1_ Net-_M1-Pad2_ Net-_M1-Pad3_ GND mosfet_n
U19  Net-_U15-Pad2_ Net-_U19-Pad2_ d_inverter
M8  Net-_M1-Pad3_ Net-_M8-Pad2_ Net-_M2-Pad1_ VDD mosfet_p
M2  Net-_M2-Pad1_ Net-_M2-Pad2_ Net-_M1-Pad3_ GND mosfet_n
U24  Net-_U16-Pad2_ Net-_U24-Pad2_ d_inverter
M15  Net-_M1-Pad3_ Net-_M15-Pad2_ Net-_M15-Pad3_ VDD mosfet_p
M9  Net-_M15-Pad3_ Net-_M9-Pad2_ Net-_M1-Pad3_ GND mosfet_n
U20  Net-_U12-Pad2_ Net-_U20-Pad2_ d_inverter
M10  Net-_M10-Pad1_ Net-_M10-Pad2_ Net-_M10-Pad3_ VDD mosfet_p
M3  Net-_M10-Pad3_ Net-_M3-Pad2_ Net-_M10-Pad1_ GND mosfet_n
U21  Net-_U13-Pad2_ Net-_U21-Pad2_ d_inverter
M11  Net-_M10-Pad1_ Net-_M11-Pad2_ Net-_M11-Pad3_ VDD mosfet_p
M4  Net-_M11-Pad3_ Net-_M4-Pad2_ Net-_M10-Pad1_ GND mosfet_n
U23  Net-_U17-Pad2_ Net-_U23-Pad2_ d_inverter
M14  Net-_M10-Pad1_ Net-_M14-Pad2_ Net-_M14-Pad3_ VDD mosfet_p
M7  Net-_M14-Pad3_ Net-_M7-Pad2_ Net-_M10-Pad1_ GND mosfet_n
U22  Net-_U10-Pad2_ Net-_U22-Pad2_ d_inverter
M13  Net-_M10-Pad1_ Net-_M13-Pad2_ Net-_M13-Pad3_ VDD mosfet_p
M5  Net-_M13-Pad3_ Net-_M5-Pad2_ Net-_M10-Pad1_ GND mosfet_n
X1  Net-_U7-Pad2_ Net-_U5-Pad2_ Net-_U3-Pad2_ Net-_U10-Pad1_ 3_and
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ d_inverter
X8  Net-_U7-Pad2_ Net-_U4-Pad2_ Net-_U3-Pad2_ Net-_U17-Pad1_ 3_and
U17  Net-_U17-Pad1_ Net-_U17-Pad2_ d_inverter
X4  Net-_U7-Pad2_ Net-_U5-Pad2_ Net-_U2-Pad2_ Net-_U13-Pad1_ 3_and
U13  Net-_U13-Pad1_ Net-_U13-Pad2_ d_inverter
X3  Net-_U7-Pad2_ Net-_U4-Pad2_ Net-_U2-Pad2_ Net-_U12-Pad1_ 3_and
U12  Net-_U12-Pad1_ Net-_U12-Pad2_ d_inverter
X7  Net-_U9-Pad2_ Net-_U5-Pad2_ Net-_U3-Pad2_ Net-_U16-Pad1_ 3_and
U16  Net-_U16-Pad1_ Net-_U16-Pad2_ d_inverter
X6  Net-_U9-Pad2_ Net-_U4-Pad2_ Net-_U3-Pad2_ Net-_U15-Pad1_ 3_and
U15  Net-_U15-Pad1_ Net-_U15-Pad2_ d_inverter
X2  Net-_U9-Pad2_ Net-_U5-Pad2_ Net-_U2-Pad2_ Net-_U11-Pad1_ 3_and
U11  Net-_U11-Pad1_ Net-_U11-Pad2_ d_inverter
X5  Net-_U9-Pad2_ Net-_U4-Pad2_ Net-_U2-Pad2_ Net-_U14-Pad1_ 3_and
U14  Net-_U14-Pad1_ Net-_U14-Pad2_ d_inverter
U30  Net-_U10-Pad2_ Net-_U22-Pad2_ Net-_M13-Pad2_ Net-_M5-Pad2_ dac_bridge_2
U31  Net-_U17-Pad2_ Net-_U23-Pad2_ Net-_M14-Pad2_ Net-_M7-Pad2_ dac_bridge_2
U29  Net-_U13-Pad2_ Net-_U21-Pad2_ Net-_M11-Pad2_ Net-_M4-Pad2_ dac_bridge_2
U28  Net-_U12-Pad2_ Net-_U20-Pad2_ Net-_M10-Pad2_ Net-_M3-Pad2_ dac_bridge_2
U32  Net-_U16-Pad2_ Net-_U24-Pad2_ Net-_M15-Pad2_ Net-_M9-Pad2_ dac_bridge_2
U27  Net-_U15-Pad2_ Net-_U19-Pad2_ Net-_M8-Pad2_ Net-_M2-Pad2_ dac_bridge_2
U26  Net-_U11-Pad2_ Net-_U18-Pad2_ Net-_M6-Pad2_ Net-_M1-Pad2_ dac_bridge_2
U33  Net-_U14-Pad2_ Net-_U25-Pad2_ Net-_M16-Pad2_ Net-_M12-Pad2_ dac_bridge_2

.end
