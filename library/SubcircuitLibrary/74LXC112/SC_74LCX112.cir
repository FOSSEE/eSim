* C:\FOSSEE2\eSim\library\SubcircuitLibrary\SC_74LCX112\SC_74LCX112.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 07/03/25 19:07:28

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
X7  Net-_U1-Pad5_ Net-_U1-Pad15_ Net-_U6-Pad2_ Net-_U8-Pad1_ 3_and
X8  Net-_U1-Pad5_ Net-_U1-Pad15_ Net-_U1-Pad1_ Net-_U8-Pad2_ 3_and
X3  Net-_U4-Pad2_ Net-_U1-Pad4_ Net-_U1-Pad6_ Net-_U2-Pad2_ 3_and
X4  Net-_U1-Pad1_ Net-_U1-Pad4_ Net-_U1-Pad6_ Net-_U2-Pad1_ 3_and
U8  Net-_U8-Pad1_ Net-_U8-Pad2_ Net-_U1-Pad6_ d_nor
U2  Net-_U2-Pad1_ Net-_U2-Pad2_ Net-_U1-Pad5_ d_nor
X1  Net-_U1-Pad6_ Net-_U1-Pad15_ Net-_U1-Pad3_ Net-_U1-Pad1_ Net-_U4-Pad1_ 4_and
U4  Net-_U4-Pad1_ Net-_U4-Pad2_ d_inverter
X9  Net-_U1-Pad5_ Net-_U1-Pad4_ Net-_U1-Pad2_ Net-_U1-Pad1_ Net-_U6-Pad1_ 4_and
U6  Net-_U6-Pad1_ Net-_U6-Pad2_ d_inverter
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ ? Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ ? PORT
X10  Net-_U1-Pad9_ Net-_U1-Pad14_ Net-_U7-Pad2_ Net-_U9-Pad1_ 3_and
X11  Net-_U1-Pad9_ Net-_U1-Pad14_ Net-_U1-Pad13_ Net-_U9-Pad2_ 3_and
X5  Net-_U5-Pad2_ Net-_U1-Pad10_ Net-_U1-Pad7_ Net-_U3-Pad2_ 3_and
X6  Net-_U1-Pad13_ Net-_U1-Pad10_ Net-_U1-Pad7_ Net-_U3-Pad1_ 3_and
U9  Net-_U9-Pad1_ Net-_U9-Pad2_ Net-_U1-Pad7_ d_nor
U3  Net-_U3-Pad1_ Net-_U3-Pad2_ Net-_U1-Pad9_ d_nor
X2  Net-_U1-Pad7_ Net-_U1-Pad14_ Net-_U1-Pad11_ Net-_U1-Pad13_ Net-_U5-Pad1_ 4_and
U5  Net-_U5-Pad1_ Net-_U5-Pad2_ d_inverter
X12  Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U7-Pad1_ 4_and
U7  Net-_U7-Pad1_ Net-_U7-Pad2_ d_inverter

.end
