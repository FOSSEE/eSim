* C:\FOSSEE\eSim\library\SubcircuitLibrary\74HC164\74HC164.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 11/29/25 10:58:58

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U7  Net-_U10-Pad7_ Net-_U11-Pad2_ VCC Net-_U11-Pad4_ Net-_U10-Pad8_ ? d_dff
U6  Net-_U3-Pad2_ Net-_U11-Pad2_ Net-_U1-Pad12_ Net-_U11-Pad4_ Net-_U10-Pad1_ ? d_dff
U8  Net-_U10-Pad1_ Net-_U11-Pad2_ Net-_U1-Pad12_ Net-_U11-Pad4_ Net-_U10-Pad2_ ? d_dff
U9  Net-_U10-Pad6_ Net-_U11-Pad2_ VCC Net-_U11-Pad4_ Net-_U10-Pad7_ ? d_dff
U11  Net-_U10-Pad2_ Net-_U11-Pad2_ Net-_U1-Pad12_ Net-_U11-Pad4_ Net-_U10-Pad3_ ? d_dff
U12  Net-_U10-Pad5_ Net-_U11-Pad2_ VCC Net-_U11-Pad4_ Net-_U10-Pad6_ ? d_dff
U13  Net-_U10-Pad3_ Net-_U11-Pad2_ Net-_U1-Pad12_ Net-_U11-Pad4_ Net-_U10-Pad4_ ? d_dff
U14  Net-_U10-Pad4_ Net-_U11-Pad2_ VCC Net-_U11-Pad4_ Net-_U10-Pad5_ Net-_U14-Pad6_ d_dff
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ Net-_U10-Pad3_ Net-_U10-Pad4_ Net-_U10-Pad5_ Net-_U10-Pad6_ Net-_U10-Pad7_ Net-_U10-Pad8_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ dac_bridge_8
U5  Net-_U1-Pad1_ Net-_U11-Pad2_ adc_bridge_1
U2  Net-_U1-Pad3_ Net-_U2-Pad2_ adc_bridge_1
U15  Net-_U10-Pad4_ Net-_U11-Pad2_ VCC Net-_U11-Pad4_ Net-_U10-Pad5_ Net-_U14-Pad6_ d_dff
U3  Net-_U1-Pad2_ Net-_U3-Pad2_ adc_bridge_1
U4  Net-_U2-Pad2_ Net-_U11-Pad4_ d_inverter
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ PORT

.end
