* C:\FOSSEE\eSim\library\SubcircuitLibrary\74148\74148.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 04/19/25 14:31:21

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U2  Net-_U2-Pad1_ Net-_U2-Pad2_ d_inverter
U11  Net-_U11-Pad1_ Net-_U11-Pad2_ Net-_U11-Pad3_ d_nor
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ Net-_U10-Pad3_ d_nor
U17  Net-_U10-Pad3_ Net-_U10-Pad3_ Net-_U17-Pad3_ d_nor
U18  Net-_U11-Pad3_ Net-_U11-Pad3_ Net-_U18-Pad3_ d_nor
U25  Net-_U17-Pad3_ Net-_U18-Pad3_ Net-_U1-Pad12_ d_nor
U13  Net-_U13-Pad1_ Net-_U13-Pad2_ Net-_U13-Pad3_ d_nor
U12  Net-_U12-Pad1_ Net-_U12-Pad2_ Net-_U12-Pad3_ d_nor
U19  Net-_U12-Pad3_ Net-_U12-Pad3_ Net-_U19-Pad3_ d_nor
U20  Net-_U13-Pad3_ Net-_U13-Pad3_ Net-_U20-Pad3_ d_nor
U26  Net-_U19-Pad3_ Net-_U20-Pad3_ Net-_U1-Pad13_ d_nor
U15  Net-_U15-Pad1_ Net-_U15-Pad2_ Net-_U15-Pad3_ d_nor
U14  Net-_U14-Pad1_ Net-_U14-Pad2_ Net-_U14-Pad3_ d_nor
U21  Net-_U14-Pad3_ Net-_U14-Pad3_ Net-_U21-Pad3_ d_nor
U22  Net-_U15-Pad3_ Net-_U15-Pad3_ Net-_U22-Pad3_ d_nor
U27  Net-_U21-Pad3_ Net-_U22-Pad3_ Net-_U1-Pad14_ d_nor
U24  Net-_U1-Pad10_ Net-_U24-Pad2_ Net-_U1-Pad11_ d_nand
X7  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U16-Pad1_ 5_and
U16  Net-_U16-Pad1_ Net-_U16-Pad2_ Net-_U16-Pad3_ d_and
U23  Net-_U16-Pad3_ Net-_U1-Pad10_ d_inverter
X5  Net-_U37-Pad2_ Net-_U2-Pad2_ Net-_U30-Pad2_ Net-_U29-Pad2_ Net-_U24-Pad2_ Net-_U10-Pad1_ 5_and
X2  Net-_U32-Pad2_ Net-_U30-Pad2_ Net-_U29-Pad2_ Net-_U24-Pad2_ Net-_U10-Pad2_ 4_and
X1  Net-_U28-Pad1_ Net-_U29-Pad2_ Net-_U24-Pad2_ Net-_U11-Pad1_ 3_and
U3  Net-_U3-Pad1_ Net-_U24-Pad2_ Net-_U11-Pad2_ d_and
X3  Net-_U2-Pad1_ Net-_U30-Pad2_ Net-_U28-Pad2_ Net-_U24-Pad2_ Net-_U12-Pad1_ 4_and
X4  Net-_U32-Pad2_ Net-_U30-Pad2_ Net-_U28-Pad2_ Net-_U24-Pad2_ Net-_U12-Pad2_ 4_and
U4  Net-_U29-Pad1_ Net-_U24-Pad2_ Net-_U13-Pad1_ d_and
U5  Net-_U3-Pad1_ Net-_U24-Pad2_ Net-_U13-Pad2_ d_and
U6  Net-_U30-Pad1_ Net-_U24-Pad2_ Net-_U14-Pad1_ d_and
U7  Net-_U28-Pad1_ Net-_U24-Pad2_ Net-_U14-Pad2_ d_and
U8  Net-_U29-Pad1_ Net-_U24-Pad2_ Net-_U15-Pad1_ d_and
U9  Net-_U3-Pad1_ Net-_U24-Pad2_ Net-_U15-Pad2_ d_and
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ PORT
U30  Net-_U30-Pad1_ Net-_U30-Pad2_ d_inverter
U28  Net-_U28-Pad1_ Net-_U28-Pad2_ d_inverter
U29  Net-_U29-Pad1_ Net-_U29-Pad2_ d_inverter
X6  Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U24-Pad2_ Net-_U16-Pad2_ 4_and
U37  Net-_U1-Pad2_ Net-_U37-Pad2_ d_inverter
U35  Net-_U1-Pad3_ Net-_U2-Pad1_ d_inverter
U32  Net-_U1-Pad4_ Net-_U32-Pad2_ d_inverter
U31  Net-_U1-Pad5_ Net-_U30-Pad1_ d_inverter
U34  Net-_U1-Pad6_ Net-_U28-Pad1_ d_inverter
U36  Net-_U1-Pad7_ Net-_U29-Pad1_ d_inverter
U33  Net-_U1-Pad8_ Net-_U3-Pad1_ d_inverter
U38  Net-_U1-Pad9_ Net-_U24-Pad2_ d_inverter

.end
