.title KiCad schematic
U112 Net-_U104-Pad2_ Net-_U106-Pad2_ Net-_U112-Pad3_ d_nand
U106 Net-_U101-Pad4_ Net-_U106-Pad2_ d_inverter
U109 Net-_U101-Pad12_ Net-_U109-Pad2_ d_inverter
U101 Net-_U101-Pad1_ Net-_U101-Pad2_ Net-_U101-Pad3_ Net-_U101-Pad4_ Net-_U101-Pad5_ Net-_U101-Pad6_ unconnected-_U101-Pad7_ Net-_U101-Pad8_ Net-_U101-Pad9_ Net-_U101-Pad10_ Net-_U101-Pad11_ Net-_U101-Pad12_ Net-_U101-Pad13_ unconnected-_U101-Pad14_ PORT
U110 Net-_U101-Pad13_ Net-_U110-Pad2_ d_inverter
U107 Net-_U101-Pad5_ Net-_U107-Pad2_ d_inverter
U108 Net-_U101-Pad11_ Net-_U108-Pad2_ d_inverter
U113 Net-_U108-Pad2_ Net-_U109-Pad2_ Net-_U113-Pad3_ d_nand
U103 Net-_U101-Pad2_ Net-_U103-Pad2_ d_inverter
U102 Net-_U101-Pad1_ Net-_U102-Pad2_ d_inverter
U114 Net-_U111-Pad3_ Net-_U111-Pad3_ Net-_U114-Pad3_ d_nand
U111 Net-_U102-Pad2_ Net-_U103-Pad2_ Net-_U111-Pad3_ d_nand
U104 Net-_U101-Pad3_ Net-_U104-Pad2_ d_inverter
U105 Net-_U101-Pad8_ Net-_U105-Pad2_ d_inverter
U115 Net-_U112-Pad3_ Net-_U112-Pad3_ Net-_U115-Pad3_ d_nand
U119 Net-_U116-Pad3_ Net-_U110-Pad2_ Net-_U119-Pad3_ d_nand
U116 Net-_U113-Pad3_ Net-_U113-Pad3_ Net-_U116-Pad3_ d_nand
U125 Net-_U122-Pad2_ Net-_U101-Pad10_ d_inverter
U122 Net-_U119-Pad3_ Net-_U122-Pad2_ d_inverter
U121 Net-_U118-Pad3_ Net-_U121-Pad2_ d_inverter
U118 Net-_U115-Pad3_ Net-_U107-Pad2_ Net-_U118-Pad3_ d_nand
U117 Net-_U114-Pad3_ Net-_U105-Pad2_ Net-_U117-Pad3_ d_nand
U124 Net-_U121-Pad2_ Net-_U101-Pad6_ d_inverter
U123 Net-_U120-Pad2_ Net-_U101-Pad9_ d_inverter
U120 Net-_U117-Pad3_ Net-_U120-Pad2_ d_inverter
.end
