* D:\FOSSEE\eSim\library\SubcircuitLibrary\L604\L604.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 12/12/24 18:31:44

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
R20  Net-_D24-Pad2_ Net-_Q15-Pad2_ 10.5k
Q15  Net-_D18-Pad1_ Net-_Q15-Pad2_ Net-_Q15-Pad3_ eSim_NPN
R23  Net-_Q15-Pad2_ Net-_Q15-Pad3_ 7.2k
R24  Net-_Q15-Pad3_ GND 3k
Q16  Net-_D18-Pad1_ Net-_Q15-Pad3_ GND eSim_NPN
D18  Net-_D18-Pad1_ COM eSim_Diode
D24  GND Net-_D24-Pad2_ eSim_Diode
U1  Net-_D1-Pad1_ Net-_D2-Pad1_ Net-_D5-Pad2_ Net-_D6-Pad2_ Net-_D10-Pad2_ Net-_D13-Pad2_ Net-_D11-Pad2_ Net-_D15-Pad2_ Net-_D12-Pad2_ Net-_D17-Pad2_ Net-_D14-Pad1_ Net-_D21-Pad2_ Net-_D16-Pad1_ Net-_D23-Pad2_ Net-_D18-Pad1_ Net-_D24-Pad2_ GND COM PORT
D22  GND Net-_D18-Pad1_ eSim_Diode
R1  Net-_D5-Pad2_ Net-_Q1-Pad2_ 10.5k
Q1  Net-_D1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
R3  Net-_Q1-Pad2_ Net-_Q1-Pad3_ 7.2k
R4  Net-_Q1-Pad3_ GND 3k
Q3  Net-_D1-Pad1_ Net-_Q1-Pad3_ GND eSim_NPN
D1  Net-_D1-Pad1_ COM eSim_Diode
D5  GND Net-_D5-Pad2_ eSim_Diode
D3  GND Net-_D1-Pad1_ eSim_Diode
R7  Net-_D13-Pad2_ Net-_Q5-Pad2_ 10.5k
Q5  Net-_D10-Pad2_ Net-_Q5-Pad2_ Net-_Q5-Pad3_ eSim_NPN
R10  Net-_Q5-Pad2_ Net-_Q5-Pad3_ 7.2k
R11  Net-_Q5-Pad3_ GND 3k
Q6  Net-_D10-Pad2_ Net-_Q5-Pad3_ GND eSim_NPN
D7  Net-_D10-Pad2_ COM eSim_Diode
D13  GND Net-_D13-Pad2_ eSim_Diode
D10  GND Net-_D10-Pad2_ eSim_Diode
R8  Net-_D15-Pad2_ Net-_Q7-Pad2_ 10.5k
Q7  Net-_D11-Pad2_ Net-_Q7-Pad2_ Net-_Q7-Pad3_ eSim_NPN
R12  Net-_Q7-Pad2_ Net-_Q7-Pad3_ 7.2k
R13  Net-_Q7-Pad3_ GND 3k
Q9  Net-_D11-Pad2_ Net-_Q7-Pad3_ GND eSim_NPN
D8  Net-_D11-Pad2_ COM eSim_Diode
D15  GND Net-_D15-Pad2_ eSim_Diode
D11  GND Net-_D11-Pad2_ eSim_Diode
R17  Net-_D23-Pad2_ Net-_Q13-Pad2_ 10.5k
Q13  Net-_D16-Pad1_ Net-_Q13-Pad2_ Net-_Q13-Pad3_ eSim_NPN
R21  Net-_Q13-Pad2_ Net-_Q13-Pad3_ 7.2k
R22  Net-_Q13-Pad3_ GND 3k
Q14  Net-_D16-Pad1_ Net-_Q13-Pad3_ GND eSim_NPN
D16  Net-_D16-Pad1_ COM eSim_Diode
D23  GND Net-_D23-Pad2_ eSim_Diode
D20  GND Net-_D16-Pad1_ eSim_Diode
R2  Net-_D6-Pad2_ Net-_Q2-Pad2_ 10.5k
Q2  Net-_D2-Pad1_ Net-_Q2-Pad2_ Net-_Q2-Pad3_ eSim_NPN
R5  Net-_Q2-Pad2_ Net-_Q2-Pad3_ 7.2k
R6  Net-_Q2-Pad3_ GND 3k
Q4  Net-_D2-Pad1_ Net-_Q2-Pad3_ GND eSim_NPN
D2  Net-_D2-Pad1_ COM eSim_Diode
D6  GND Net-_D6-Pad2_ eSim_Diode
D4  GND Net-_D2-Pad1_ eSim_Diode
R9  Net-_D17-Pad2_ Net-_Q8-Pad2_ 10.5k
Q8  Net-_D12-Pad2_ Net-_Q8-Pad2_ Net-_Q10-Pad2_ eSim_NPN
R14  Net-_Q8-Pad2_ Net-_Q10-Pad2_ 7.2k
R15  Net-_Q10-Pad2_ GND 3k
Q10  Net-_D12-Pad2_ Net-_Q10-Pad2_ GND eSim_NPN
D9  Net-_D12-Pad2_ COM eSim_Diode
D17  GND Net-_D17-Pad2_ eSim_Diode
D12  GND Net-_D12-Pad2_ eSim_Diode
R16  Net-_D21-Pad2_ Net-_Q11-Pad2_ 10.5k
Q11  Net-_D14-Pad1_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_NPN
R18  Net-_Q11-Pad2_ Net-_Q11-Pad3_ 7.2k
R19  Net-_Q11-Pad3_ GND 3k
Q12  Net-_D14-Pad1_ Net-_Q11-Pad3_ GND eSim_NPN
D14  Net-_D14-Pad1_ COM eSim_Diode
D21  GND Net-_D21-Pad2_ eSim_Diode
D19  GND Net-_D14-Pad1_ eSim_Diode

.end
