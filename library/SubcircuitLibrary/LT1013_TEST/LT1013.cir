.title KiCad schematic
Q77 Net-_C10-Pad2_ Net-_Q77-Pad2_ Net-_C1-Pad2_ eSim_NPN
R45 Net-_C1-Pad2_ Net-_Q85-Pad3_ 600
R41 Net-_C1-Pad2_ Net-_Q15-Pad2_ 42k
Q74 Net-_J2-Pad3_ Net-_Q74-Pad2_ Net-_Q12-Pad2_ eSim_PNP
Q71 Net-_J1-Pad1_ Net-_C6-Pad1_ Net-_Q66-Pad2_ eSim_NPN
R22 Net-_C1-Pad2_ Net-_Q46-Pad3_ 2k
Q49 Net-_C6-Pad1_ Net-_Q44-Pad3_ Net-_C1-Pad2_ eSim_NPN
Q46 Net-_Q44-Pad3_ Net-_C10-Pad2_ Net-_Q46-Pad3_ eSim_NPN
C4 Net-_C4-Pad1_ Net-_C1-Pad2_ 10p
Q38 Net-_C4-Pad1_ Net-_C2-Pad1_ Net-_Q38-Pad3_ eSim_NPN
Q41 Net-_C1-Pad2_ Net-_C4-Pad1_ Net-_C6-Pad2_ eSim_PNP
R16 Net-_C1-Pad2_ Net-_Q38-Pad3_ 5k
Q64 Net-_Q63-Pad3_ Net-_C10-Pad2_ Net-_Q64-Pad3_ eSim_NPN
R38 Net-_C1-Pad2_ Net-_Q68-Pad2_ 30k
C12 Net-_C12-Pad1_ Net-_C1-Pad2_ 10p
Q53 Net-_C10-Pad1_ Net-_C10-Pad2_ Net-_Q53-Pad3_ eSim_NPN
R28 Net-_C1-Pad2_ Net-_Q53-Pad3_ 1.3k
R34 Net-_C1-Pad2_ Net-_Q64-Pad3_ 2k
Q68 Net-_C10-Pad1_ Net-_Q68-Pad2_ Net-_C1-Pad2_ eSim_NPN
J2 Net-_J1-Pad1_ Net-_C1-Pad2_ Net-_J2-Pad3_ eSim_NJF
R42 Net-_Q15-Pad2_ Net-_Q78-Pad3_ 14k
Q86 Net-_Q74-Pad2_ Net-_Q12-Pad2_ Net-_Q86-Pad3_ eSim_PNP
Q85 Net-_Q77-Pad2_ Net-_C10-Pad2_ Net-_Q85-Pad3_ eSim_NPN
Q80 Net-_J2-Pad3_ Net-_Q78-Pad3_ Net-_C10-Pad2_ eSim_NPN
Q84 Net-_Q74-Pad2_ Net-_Q78-Pad3_ Net-_Q77-Pad2_ eSim_NPN
Q78 Net-_J1-Pad1_ Net-_J2-Pad3_ Net-_Q78-Pad3_ eSim_NPN
Q72 Net-_Q66-Pad3_ Net-_Q63-Pad3_ Net-_Q68-Pad2_ eSim_NPN
Q63 Net-_J1-Pad1_ Net-_C10-Pad1_ Net-_Q63-Pad3_ eSim_NPN
U1 Net-_Q65-Pad3_ Net-_R1-Pad1_ Net-_R3-Pad1_ Net-_C1-Pad2_ Net-_R4-Pad1_ Net-_R2-Pad1_ Net-_Q66-Pad3_ Net-_J1-Pad1_ PORT
C10 Net-_C10-Pad1_ Net-_C10-Pad2_ 4p
R30 Net-_C12-Pad1_ Net-_C10-Pad1_ 2k
Q82 Net-_Q75-Pad2_ Net-_C9-Pad2_ Net-_Q82-Pad3_ eSim_NPN
Q83 Net-_Q73-Pad2_ Net-_Q11-Pad2_ Net-_Q83-Pad3_ eSim_PNP
R39 Net-_C1-Pad2_ Net-_Q13-Pad2_ 42k
Q81 Net-_Q73-Pad2_ Net-_Q76-Pad3_ Net-_Q75-Pad2_ eSim_NPN
R43 Net-_C1-Pad2_ Net-_Q82-Pad3_ 600
R46 Net-_Q86-Pad3_ Net-_J1-Pad1_ 800
Q59 Net-_Q55-Pad2_ Net-_C5-Pad1_ Net-_Q59-Pad3_ eSim_NPN
Q70 Net-_Q65-Pad3_ Net-_Q61-Pad3_ Net-_Q67-Pad2_ eSim_NPN
Q57 Net-_Q55-Pad2_ Net-_Q55-Pad2_ Net-_Q52-Pad3_ eSim_PNP
Q55 Net-_C5-Pad1_ Net-_Q55-Pad2_ Net-_Q52-Pad3_ eSim_PNP
C9 Net-_C9-Pad1_ Net-_C9-Pad2_ 4p
Q75 Net-_C9-Pad2_ Net-_Q75-Pad2_ Net-_C1-Pad2_ eSim_NPN
Q69 Net-_J1-Pad1_ Net-_C5-Pad1_ Net-_Q65-Pad2_ eSim_NPN
R35 Net-_Q65-Pad3_ Net-_Q65-Pad2_ 18
Q65 Net-_C5-Pad1_ Net-_Q65-Pad2_ Net-_Q65-Pad3_ eSim_NPN
R31 Net-_Q65-Pad3_ Net-_Q59-Pad3_ 2.4k
R40 Net-_Q13-Pad2_ Net-_Q76-Pad3_ 14k
Q79 Net-_J1-Pad3_ Net-_Q76-Pad3_ Net-_C9-Pad2_ eSim_NPN
R23 Net-_Q48-Pad3_ Net-_J1-Pad1_ 100
R25 Net-_J1-Pad1_ Net-_Q52-Pad3_ 1k
Q40 Net-_C5-Pad2_ Net-_Q11-Pad2_ Net-_Q40-Pad3_ eSim_PNP
R17 Net-_Q40-Pad3_ Net-_J1-Pad1_ 1.6k
C5 Net-_C5-Pad1_ Net-_C5-Pad2_ 2.5p
Q43 Net-_J1-Pad1_ Net-_C5-Pad2_ Net-_Q43-Pad3_ eSim_NPN
C7 Net-_C5-Pad1_ Net-_C7-Pad2_ 21p
R19 Net-_C3-Pad1_ Net-_C7-Pad2_ 3.9k
Q48 Net-_C5-Pad1_ Net-_Q11-Pad2_ Net-_Q48-Pad3_ eSim_PNP
Q52 Net-_C9-Pad1_ Net-_Q11-Pad2_ Net-_Q52-Pad3_ eSim_PNP
Q76 Net-_J1-Pad1_ Net-_J1-Pad3_ Net-_Q76-Pad3_ eSim_NPN
Q73 Net-_J1-Pad3_ Net-_Q73-Pad2_ Net-_Q11-Pad2_ eSim_PNP
J1 Net-_J1-Pad1_ Net-_C1-Pad2_ Net-_J1-Pad3_ eSim_NJF
R44 Net-_Q83-Pad3_ Net-_J1-Pad1_ 800
R36 Net-_C1-Pad2_ Net-_Q67-Pad2_ 30k
R32 Net-_C1-Pad2_ Net-_Q62-Pad3_ 2k
Q67 Net-_C9-Pad1_ Net-_Q67-Pad2_ Net-_C1-Pad2_ eSim_NPN
R26 Net-_C1-Pad2_ Net-_Q51-Pad3_ 1.3k
C11 Net-_C11-Pad1_ Net-_C1-Pad2_ 10p
Q56 Net-_C6-Pad1_ Net-_Q56-Pad2_ Net-_Q54-Pad3_ eSim_PNP
R27 Net-_J1-Pad1_ Net-_Q54-Pad3_ 1k
Q62 Net-_Q61-Pad3_ Net-_C9-Pad2_ Net-_Q62-Pad3_ eSim_NPN
Q61 Net-_J1-Pad1_ Net-_C9-Pad1_ Net-_Q61-Pad3_ eSim_NPN
R29 Net-_C11-Pad1_ Net-_C9-Pad1_ 2k
Q51 Net-_C9-Pad1_ Net-_C9-Pad2_ Net-_Q51-Pad3_ eSim_NPN
R18 Net-_Q42-Pad3_ Net-_J1-Pad1_ 1.6k
R24 Net-_Q50-Pad3_ Net-_J1-Pad1_ 100
Q44 Net-_J1-Pad1_ Net-_C6-Pad2_ Net-_Q44-Pad3_ eSim_NPN
Q50 Net-_C6-Pad1_ Net-_Q12-Pad2_ Net-_Q50-Pad3_ eSim_PNP
Q36 Net-_C4-Pad1_ Net-_Q12-Pad1_ Net-_Q28-Pad3_ eSim_PNP
Q42 Net-_C6-Pad2_ Net-_Q12-Pad2_ Net-_Q42-Pad3_ eSim_PNP
C8 Net-_C6-Pad1_ Net-_C8-Pad2_ 21p
R20 Net-_C4-Pad1_ Net-_C8-Pad2_ 3.9k
C6 Net-_C6-Pad1_ Net-_C6-Pad2_ 2.5p
Q66 Net-_C6-Pad1_ Net-_Q66-Pad2_ Net-_Q66-Pad3_ eSim_NPN
R37 Net-_Q66-Pad3_ Net-_Q66-Pad2_ 18
Q58 Net-_Q56-Pad2_ Net-_Q56-Pad2_ Net-_Q54-Pad3_ eSim_PNP
Q54 Net-_C10-Pad1_ Net-_Q12-Pad2_ Net-_Q54-Pad3_ eSim_PNP
Q60 Net-_Q56-Pad2_ Net-_C6-Pad1_ Net-_Q60-Pad3_ eSim_NPN
R33 Net-_Q66-Pad3_ Net-_Q60-Pad3_ 2.4k
Q39 Net-_C1-Pad2_ Net-_C3-Pad1_ Net-_C5-Pad2_ eSim_PNP
Q45 Net-_Q43-Pad3_ Net-_C9-Pad2_ Net-_Q45-Pad3_ eSim_NPN
R21 Net-_C1-Pad2_ Net-_Q45-Pad3_ 2k
Q47 Net-_C5-Pad1_ Net-_Q43-Pad3_ Net-_C1-Pad2_ eSim_NPN
R15 Net-_C1-Pad2_ Net-_Q37-Pad3_ 5k
R13 Net-_C1-Pad2_ Net-_Q30-Pad3_ 5k
C3 Net-_C3-Pad1_ Net-_C1-Pad2_ 10p
Q37 Net-_C3-Pad1_ Net-_C1-Pad1_ Net-_Q37-Pad3_ eSim_NPN
Q2 Net-_C1-Pad2_ Net-_Q2-Pad2_ Net-_Q2-Pad3_ eSim_PNP
R2 Net-_R2-Pad1_ Net-_Q2-Pad2_ 400
R4 Net-_R4-Pad1_ Net-_Q10-Pad2_ 400
Q5 Net-_Q2-Pad3_ Net-_Q12-Pad2_ Net-_Q5-Pad3_ eSim_PNP
Q28 Net-_C2-Pad1_ Net-_Q2-Pad3_ Net-_Q28-Pad3_ eSim_PNP
Q34 Net-_Q28-Pad3_ Net-_Q12-Pad2_ Net-_Q34-Pad3_ eSim_PNP
Q20 Net-_Q19-Pad3_ Net-_Q12-Pad2_ Net-_Q20-Pad3_ eSim_PNP
R12 Net-_Q34-Pad3_ Net-_J1-Pad1_ 1.6k
R10 Net-_Q20-Pad3_ Net-_J1-Pad1_ 1.6k
R8 Net-_Q12-Pad3_ Net-_J1-Pad1_ 9k
R6 Net-_Q5-Pad3_ Net-_J1-Pad1_ 9k
C2 Net-_C2-Pad1_ Net-_C1-Pad2_ 75p
Q19 Net-_Q19-Pad1_ Net-_Q19-Pad1_ Net-_Q19-Pad3_ eSim_PNP
Q10 Net-_C1-Pad2_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_PNP
Q15 Net-_J1-Pad1_ Net-_Q15-Pad2_ Net-_Q15-Pad3_ eSim_NPN
Q8 Net-_C1-Pad2_ Net-_Q10-Pad2_ Net-_Q12-Pad1_ eSim_PNP
Q12 Net-_Q12-Pad1_ Net-_Q12-Pad2_ Net-_Q12-Pad3_ eSim_PNP
Q6 Net-_C1-Pad2_ Net-_Q2-Pad2_ Net-_Q15-Pad3_ eSim_PNP
Q16 Net-_C6-Pad1_ Net-_Q15-Pad2_ Net-_Q10-Pad3_ eSim_NPN
Q22 Net-_C2-Pad1_ Net-_Q19-Pad1_ Net-_Q19-Pad3_ eSim_PNP
Q32 Net-_J1-Pad1_ Net-_C4-Pad1_ Net-_C2-Pad1_ eSim_NPN
Q26 Net-_C1-Pad2_ Net-_C2-Pad1_ Net-_Q25-Pad3_ eSim_PNP
Q33 Net-_C2-Pad1_ Net-_C2-Pad1_ Net-_Q33-Pad3_ eSim_NPN
R14 Net-_C1-Pad2_ Net-_Q33-Pad3_ 5k
Q25 Net-_Q19-Pad3_ Net-_Q19-Pad1_ Net-_Q25-Pad3_ eSim_NPN
C1 Net-_C1-Pad1_ Net-_C1-Pad2_ 75p
Q24 Net-_C1-Pad2_ Net-_C1-Pad1_ Net-_Q23-Pad3_ eSim_PNP
Q30 Net-_C1-Pad1_ Net-_C1-Pad1_ Net-_Q30-Pad3_ eSim_NPN
Q23 Net-_Q17-Pad3_ Net-_Q17-Pad1_ Net-_Q23-Pad3_ eSim_NPN
Q21 Net-_C1-Pad1_ Net-_Q17-Pad1_ Net-_Q17-Pad3_ eSim_PNP
Q13 Net-_J1-Pad1_ Net-_Q13-Pad2_ Net-_Q13-Pad3_ eSim_NPN
Q11 Net-_Q11-Pad1_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_PNP
Q18 Net-_Q17-Pad3_ Net-_Q11-Pad2_ Net-_Q18-Pad3_ eSim_PNP
Q9 Net-_C1-Pad2_ Net-_Q7-Pad2_ Net-_Q14-Pad3_ eSim_PNP
Q14 Net-_C5-Pad1_ Net-_Q13-Pad2_ Net-_Q14-Pad3_ eSim_NPN
Q7 Net-_C1-Pad2_ Net-_Q7-Pad2_ Net-_Q11-Pad1_ eSim_PNP
Q29 Net-_J1-Pad1_ Net-_C3-Pad1_ Net-_C1-Pad1_ eSim_NPN
Q17 Net-_Q17-Pad1_ Net-_Q17-Pad1_ Net-_Q17-Pad3_ eSim_PNP
Q27 Net-_C1-Pad1_ Net-_Q1-Pad3_ Net-_Q27-Pad3_ eSim_PNP
Q35 Net-_C3-Pad1_ Net-_Q11-Pad1_ Net-_Q27-Pad3_ eSim_PNP
R3 Net-_R3-Pad1_ Net-_Q7-Pad2_ 400
R1 Net-_R1-Pad1_ Net-_Q1-Pad2_ 400
Q4 Net-_C1-Pad2_ Net-_Q1-Pad2_ Net-_Q13-Pad3_ eSim_PNP
Q1 Net-_C1-Pad2_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_PNP
R7 Net-_Q11-Pad3_ Net-_J1-Pad1_ 9k
Q3 Net-_Q1-Pad3_ Net-_Q11-Pad2_ Net-_Q3-Pad3_ eSim_PNP
R11 Net-_Q31-Pad3_ Net-_J1-Pad1_ 1.6k
Q31 Net-_Q27-Pad3_ Net-_Q11-Pad2_ Net-_Q31-Pad3_ eSim_PNP
R9 Net-_Q18-Pad3_ Net-_J1-Pad1_ 1.6k
R5 Net-_Q3-Pad3_ Net-_J1-Pad1_ 9k
.end
