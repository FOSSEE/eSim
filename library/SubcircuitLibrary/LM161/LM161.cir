* C:\Users\AJAY\OneDrive\Desktop\FOSSEE2.3\eSim\library\SubcircuitLibrary\LM161\LM161.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 11/29/25 18:37:37

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
Q3  Net-_Q3-Pad1_ Net-_D1-Pad1_ Net-_Q3-Pad3_ eSim_NPN
R4  Net-_Q3-Pad1_ Net-_D1-Pad1_ 9k
D1  Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
D2  Net-_D1-Pad2_ Net-_D2-Pad2_ eSim_Diode
D3  Net-_D2-Pad2_ Net-_D3-Pad2_ eSim_Diode
R3  Net-_Q3-Pad3_ Net-_Q4-Pad1_ 1450
U2  GND Net-_D3-Pad2_ zener
Q5  Net-_Q3-Pad1_ Net-_Q4-Pad1_ Net-_Q5-Pad3_ eSim_NPN
R1  Net-_Q3-Pad3_ Net-_Q1-Pad1_ 1450
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
Q4  Net-_Q4-Pad1_ Net-_Q4-Pad2_ Net-_Q1-Pad3_ eSim_NPN
Q2  Net-_Q1-Pad3_ Net-_Q2-Pad2_ Net-_Q2-Pad3_ eSim_NPN
R2  Net-_Q2-Pad3_ Net-_Q11-Pad3_ 400
U3  Net-_Q13-Pad2_ Net-_Q5-Pad3_ zener
Q6  Net-_Q13-Pad2_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_NPN
Q7  Net-_Q3-Pad1_ Net-_Q1-Pad1_ Net-_Q7-Pad3_ eSim_NPN
U4  Net-_Q8-Pad1_ Net-_Q7-Pad3_ zener
Q8  Net-_Q8-Pad1_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_NPN
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad2_ GND eSim_NPN
Q12  Net-_Q12-Pad1_ Net-_Q12-Pad2_ GND eSim_NPN
Q13  Net-_Q12-Pad2_ Net-_Q13-Pad2_ Net-_Q11-Pad1_ eSim_NPN
R6  Net-_Q10-Pad1_ Net-_Q10-Pad2_ 1.3k
R8  Net-_Q12-Pad1_ Net-_Q12-Pad2_ 1.3k
R5  Net-_Q28-Pad1_ Net-_Q10-Pad1_ 1k
Q11  Net-_Q11-Pad1_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_NPN
R7  Net-_Q28-Pad1_ Net-_Q12-Pad1_ 1k
Q9  Net-_Q10-Pad2_ Net-_Q8-Pad1_ Net-_Q11-Pad1_ eSim_NPN
Q14  Net-_Q14-Pad1_ Net-_Q14-Pad2_ Net-_Q10-Pad1_ eSim_NPN
Q15  Net-_Q14-Pad1_ Net-_Q14-Pad2_ Net-_D5-Pad2_ eSim_NPN
Q17  Net-_Q14-Pad1_ Net-_Q14-Pad2_ Net-_Q17-Pad3_ eSim_NPN
R9  Net-_Q28-Pad1_ Net-_Q14-Pad2_ 4k
R11  Net-_Q28-Pad1_ Net-_Q17-Pad3_ 1.4k
Q19  Net-_Q17-Pad3_ Net-_Q14-Pad1_ Net-_Q19-Pad3_ eSim_NPN
Q21  Net-_Q17-Pad3_ Net-_Q14-Pad1_ Net-_D4-Pad1_ eSim_NPN
R12  Net-_Q19-Pad3_ Net-_Q24-Pad2_ 235
R13  Net-_Q24-Pad2_ GND 800
D4  Net-_D4-Pad1_ Net-_D4-Pad2_ eSim_Diode
Q24  Net-_D4-Pad2_ Net-_Q24-Pad2_ GND eSim_NPN
Q23  Net-_Q23-Pad1_ Net-_Q17-Pad3_ Net-_D4-Pad1_ eSim_NPN
R14  Net-_Q28-Pad1_ Net-_Q23-Pad1_ 100
D6  GND Net-_D6-Pad2_ eSim_Diode
D5  GND Net-_D5-Pad2_ eSim_Diode
Q16  Net-_Q16-Pad1_ Net-_Q16-Pad2_ Net-_Q12-Pad1_ eSim_NPN
Q18  Net-_Q16-Pad1_ Net-_Q16-Pad2_ Net-_D6-Pad2_ eSim_NPN
Q20  Net-_Q16-Pad1_ Net-_Q16-Pad2_ Net-_Q20-Pad3_ eSim_NPN
R10  Net-_Q28-Pad1_ Net-_Q16-Pad2_ 1k
R15  Net-_Q28-Pad1_ Net-_Q20-Pad3_ 1.4k
Q22  Net-_Q20-Pad3_ Net-_Q16-Pad1_ Net-_Q22-Pad3_ eSim_NPN
Q25  Net-_Q20-Pad3_ Net-_Q16-Pad1_ Net-_D7-Pad1_ eSim_NPN
R17  Net-_Q27-Pad2_ Net-_Q22-Pad3_ 235
D7  Net-_D7-Pad1_ Net-_D7-Pad2_ eSim_Diode
Q27  Net-_D7-Pad2_ Net-_Q27-Pad2_ GND eSim_NPN
R16  Net-_Q27-Pad2_ GND 800
Q26  Net-_Q26-Pad1_ Net-_Q20-Pad3_ Net-_D7-Pad1_ eSim_NPN
R18  Net-_Q28-Pad1_ Net-_Q26-Pad1_ 100
Q28  Net-_Q28-Pad1_ Net-_Q28-Pad2_ Net-_Q28-Pad3_ eSim_NPN
R21  Net-_Q28-Pad1_ Net-_Q28-Pad2_ 5k
R19  Net-_Q28-Pad3_ Net-_Q2-Pad2_ 3.2k
U5  Net-_Q11-Pad3_ Net-_Q28-Pad2_ zener
R20  Net-_Q2-Pad2_ Net-_Q11-Pad2_ 387
Q29  Net-_Q11-Pad2_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_NPN
U1  Net-_Q3-Pad1_ ? Net-_Q1-Pad2_ Net-_Q4-Pad2_ ? Net-_Q11-Pad3_ ? Net-_D6-Pad2_ Net-_D7-Pad2_ GND Net-_D4-Pad2_ ? Net-_D5-Pad2_ Net-_Q28-Pad1_ PORT

.end
