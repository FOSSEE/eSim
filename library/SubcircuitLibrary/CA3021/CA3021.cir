* C:\Users\AJAY\OneDrive\Desktop\FOSSEE2.3\eSim\library\SubcircuitLibrary\CA3021\CA3021.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 01/10/26 20:30:04

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
R1  Net-_Q1-Pad1_ Net-_R1-Pad2_ 3.9k
R3  Net-_Q1-Pad2_ Net-_R1-Pad2_ 15k
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
R2  Net-_R1-Pad2_ Net-_D1-Pad1_ 3.9k
D1  Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
R5  Net-_R11-Pad1_ Net-_Q1-Pad1_ 34k
R6  Net-_R11-Pad1_ Net-_Q3-Pad1_ 0.1k
Q3  Net-_Q3-Pad1_ Net-_Q1-Pad1_ Net-_D3-Pad2_ eSim_NPN
Q2  Net-_Q1-Pad3_ Net-_Q2-Pad2_ Net-_D1-Pad2_ eSim_NPN
R4  Net-_Q2-Pad2_ Net-_R4-Pad2_ 5k
R9  Net-_Q5-Pad2_ Net-_R4-Pad2_ 5k
R7  Net-_D3-Pad2_ Net-_D1-Pad2_ 3.9k
R8  Net-_R4-Pad2_ Net-_R8-Pad2_ 5k
Q5  Net-_Q5-Pad1_ Net-_Q5-Pad2_ Net-_D1-Pad2_ eSim_NPN
R10  Net-_Q4-Pad3_ Net-_Q5-Pad1_ 0.75k
Q4  Net-_Q4-Pad1_ Net-_D3-Pad2_ Net-_Q4-Pad3_ eSim_NPN
D3  Net-_D3-Pad1_ Net-_D3-Pad2_ eSim_Diode
R11  Net-_R11-Pad1_ Net-_Q4-Pad1_ 75k
Q6  Net-_Q6-Pad1_ Net-_Q4-Pad1_ Net-_Q6-Pad3_ eSim_NPN
R12  Net-_R11-Pad1_ Net-_Q6-Pad1_ 0.3k
R13  Net-_Q6-Pad3_ Net-_D1-Pad2_ 3.9k
D2  Net-_D2-Pad1_ Net-_D2-Pad2_ eSim_Diode
U1  Net-_Q1-Pad2_ Net-_R8-Pad2_ Net-_Q1-Pad1_ Net-_D2-Pad1_ Net-_R11-Pad1_ Net-_D2-Pad2_ Net-_Q4-Pad1_ Net-_Q6-Pad3_ Net-_D3-Pad1_ Net-_Q5-Pad1_ Net-_D1-Pad2_ Net-_Q1-Pad3_ PORT

.end
