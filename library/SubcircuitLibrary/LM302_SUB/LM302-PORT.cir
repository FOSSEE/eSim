* C:\FOSSEE2\eSim\library\SubcircuitLibrary\LM302-PORT\LM302-PORT.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 05/31/24 14:46:27

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad1_ Net-_J1-Pad2_ eSim_NPN
Q2  Net-_Q15-Pad2_ Net-_Q1-Pad1_ Net-_J1-Pad3_ eSim_PNP
Q3  Net-_Q11-Pad2_ Net-_J1-Pad3_ Net-_Q3-Pad3_ eSim_NPN
R1  Net-_J1-Pad1_ Net-_Q4-Pad3_ 1k
R3  Net-_J1-Pad1_ Net-_J1-Pad1_ 500
R7  Net-_J1-Pad1_ Net-_J1-Pad1_ 500
R8  Net-_J1-Pad1_ Net-_Q8-Pad3_ 1k
Q4  Net-_Q11-Pad2_ Net-_Q11-Pad3_ Net-_Q4-Pad3_ eSim_PNP
Q8  Net-_Q11-Pad3_ Net-_Q11-Pad3_ Net-_Q8-Pad3_ eSim_PNP
J1  Net-_J1-Pad1_ Net-_J1-Pad2_ Net-_J1-Pad3_ jfet_n
R2  Net-_Q3-Pad3_ Net-_J1-Pad2_ 3k
Q11  Net-_C1-Pad1_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_PNP
D1  Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
Q5  Net-_D1-Pad2_ Net-_D1-Pad1_ Net-_Q5-Pad3_ eSim_NPN
R4  Net-_Q5-Pad3_ Net-_Q10-Pad1_ 200k
Q6  Net-_D1-Pad2_ Net-_Q5-Pad3_ Net-_Q6-Pad3_ eSim_NPN
R5  Net-_Q6-Pad3_ Net-_Q10-Pad3_ 150
Q9  Net-_Q12-Pad1_ Net-_Q12-Pad3_ Net-_Q6-Pad3_ eSim_NPN
Q12  Net-_Q12-Pad1_ Net-_C1-Pad2_ Net-_Q12-Pad3_ eSim_NPN
R9  Net-_Q12-Pad3_ Net-_Q10-Pad1_ 200k
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad1_ Net-_Q10-Pad3_ eSim_NPN
Q7  Net-_Q10-Pad3_ Net-_J1-Pad3_ Net-_Q7-Pad3_ eSim_NPN
R6  Net-_Q7-Pad3_ Net-_J1-Pad2_ 1.5k
Q13  Net-_Q13-Pad1_ Net-_Q13-Pad1_ Net-_D1-Pad1_ eSim_NPN
Q15  Net-_Q13-Pad1_ Net-_Q15-Pad2_ Net-_Q15-Pad3_ eSim_NPN
R11  Net-_Q15-Pad3_ Net-_J1-Pad2_ 200
Q14  Net-_C1-Pad1_ Net-_Q14-Pad2_ Net-_Q12-Pad1_ eSim_NPN
Q18  Net-_J1-Pad1_ Net-_Q14-Pad2_ Net-_D1-Pad2_ eSim_NPN
Q17  Net-_J1-Pad1_ Net-_C1-Pad1_ Net-_Q14-Pad2_ eSim_NPN
Q16  Net-_C1-Pad1_ Net-_D1-Pad2_ Net-_Q13-Pad1_ eSim_NPN
R10  Net-_C1-Pad2_ Net-_Q13-Pad1_ 5k
R13  Net-_D1-Pad2_ Net-_Q13-Pad1_ 25
R12  Net-_Q14-Pad2_ Net-_D1-Pad2_ 3k
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 10p
U1  Net-_J1-Pad1_ Net-_J1-Pad2_ Net-_D1-Pad1_ Net-_J1-Pad2_ Net-_Q15-Pad3_ Net-_Q13-Pad1_ Net-_J1-Pad1_ Net-_J1-Pad1_ PORT

.end
