* C:\Users\chand\eSim\FOSSEE\eSim\library\SubcircuitLibrary\ULN2804\ULN2804.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 02/21/26 13:13:00

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
Q2  Net-_C1-Pad1_ Net-_Q1-Pad3_ GND eSim_NPN
Q1  Net-_C1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
R2  Net-_Q1-Pad3_ Net-_Q1-Pad2_ 7.2k
R3  GND Net-_Q1-Pad3_ 3k
R1  Net-_Q1-Pad2_ Net-_R1-Pad2_ 10.5k
C1  Net-_C1-Pad1_ GND 15pF
D1  GND Net-_C1-Pad1_ eSim_Diode
R4  VCC Net-_C1-Pad1_ 1k
U1  Net-_R1-Pad2_ Net-_R9-Pad2_ Net-_R17-Pad2_ Net-_R25-Pad2_ Net-_R5-Pad2_ Net-_R12-Pad2_ Net-_R20-Pad2_ Net-_R28-Pad2_ GND VCC Net-_C8-Pad1_ Net-_C6-Pad1_ Net-_C4-Pad1_ Net-_C2-Pad1_ Net-_C7-Pad1_ Net-_C5-Pad1_ Net-_C3-Pad1_ Net-_C1-Pad1_ PORT
Q7  Net-_C3-Pad1_ Net-_Q5-Pad3_ GND eSim_NPN
Q5  Net-_C3-Pad1_ Net-_Q5-Pad2_ Net-_Q5-Pad3_ eSim_NPN
R10  Net-_Q5-Pad3_ Net-_Q5-Pad2_ 7.2k
R11  GND Net-_Q5-Pad3_ 3k
R9  Net-_Q5-Pad2_ Net-_R9-Pad2_ 10.5k
C3  Net-_C3-Pad1_ GND 15pF
D3  GND Net-_C3-Pad1_ eSim_Diode
R15  VCC Net-_C3-Pad1_ 1k
Q11  Net-_C5-Pad1_ Net-_Q11-Pad2_ GND eSim_NPN
Q9  Net-_C5-Pad1_ Net-_Q9-Pad2_ Net-_Q11-Pad2_ eSim_NPN
R18  Net-_Q11-Pad2_ Net-_Q9-Pad2_ 7.2k
R19  GND Net-_Q11-Pad2_ 3k
R17  Net-_Q9-Pad2_ Net-_R17-Pad2_ 10.5k
C5  Net-_C5-Pad1_ GND 15pF
D5  GND Net-_C5-Pad1_ eSim_Diode
R23  VCC Net-_C5-Pad1_ 1k
Q15  Net-_C7-Pad1_ Net-_Q13-Pad3_ GND eSim_NPN
Q13  Net-_C7-Pad1_ Net-_Q13-Pad2_ Net-_Q13-Pad3_ eSim_NPN
R26  Net-_Q13-Pad3_ Net-_Q13-Pad2_ 7.2k
R27  GND Net-_Q13-Pad3_ 3k
R25  Net-_Q13-Pad2_ Net-_R25-Pad2_ 10.5k
C7  Net-_C7-Pad1_ GND 15pF
D7  GND Net-_C7-Pad1_ eSim_Diode
R31  VCC Net-_C7-Pad1_ 1k
Q4  Net-_C2-Pad1_ Net-_Q3-Pad3_ GND eSim_NPN
Q3  Net-_C2-Pad1_ Net-_Q3-Pad2_ Net-_Q3-Pad3_ eSim_NPN
R6  Net-_Q3-Pad3_ Net-_Q3-Pad2_ 7.2k
R7  GND Net-_Q3-Pad3_ 3k
R5  Net-_Q3-Pad2_ Net-_R5-Pad2_ 10.5k
C2  Net-_C2-Pad1_ GND 15pF
D2  GND Net-_C2-Pad1_ eSim_Diode
R8  VCC Net-_C2-Pad1_ 1k
Q8  Net-_C4-Pad1_ Net-_Q6-Pad3_ GND eSim_NPN
Q6  Net-_C4-Pad1_ Net-_Q6-Pad2_ Net-_Q6-Pad3_ eSim_NPN
R13  Net-_Q6-Pad3_ Net-_Q6-Pad2_ 7.2k
R14  GND Net-_Q6-Pad3_ 3k
R12  Net-_Q6-Pad2_ Net-_R12-Pad2_ 10.5k
C4  Net-_C4-Pad1_ GND 15pF
D4  GND Net-_C4-Pad1_ eSim_Diode
R16  VCC Net-_C4-Pad1_ 1k
Q12  Net-_C6-Pad1_ Net-_Q10-Pad3_ GND eSim_NPN
Q10  Net-_C6-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
R21  Net-_Q10-Pad3_ Net-_Q10-Pad2_ 7.2k
R22  GND Net-_Q10-Pad3_ 3k
R20  Net-_Q10-Pad2_ Net-_R20-Pad2_ 10.5k
C6  Net-_C6-Pad1_ GND 15pF
D6  GND Net-_C6-Pad1_ eSim_Diode
R24  VCC Net-_C6-Pad1_ 1k
Q16  Net-_C8-Pad1_ Net-_Q14-Pad3_ GND eSim_NPN
Q14  Net-_C8-Pad1_ Net-_Q14-Pad2_ Net-_Q14-Pad3_ eSim_NPN
R29  Net-_Q14-Pad3_ Net-_Q14-Pad2_ 7.2k
R30  GND Net-_Q14-Pad3_ 3k
R28  Net-_Q14-Pad2_ Net-_R28-Pad2_ 10.5k
C8  Net-_C8-Pad1_ GND 15pF
D8  GND Net-_C8-Pad1_ eSim_Diode
R32  VCC Net-_C8-Pad1_ 1k

.end
