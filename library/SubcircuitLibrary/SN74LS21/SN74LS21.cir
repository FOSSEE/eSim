* D:\FOSSEE\eSim\library\SubcircuitLibrary\SN74LS21\SN74LS21.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 02/03/25 21:07:27

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
R5  Net-_R1-Pad1_ Net-_D10-Pad1_ 20k
R6  Net-_R1-Pad1_ Net-_Q6-Pad2_ 10k
R7  Net-_R1-Pad1_ Net-_Q2-Pad2_ 8k
R8  Net-_R1-Pad1_ Net-_Q2-Pad1_ 75
Q2  Net-_Q2-Pad1_ Net-_Q2-Pad2_ Net-_D5-Pad1_ eSim_NPN
Q5  Net-_Q2-Pad1_ Net-_D5-Pad1_ Net-_Q10-Pad1_ eSim_NPN
R10  Net-_Q10-Pad1_ Net-_D5-Pad1_ 4.5k
Q10  Net-_Q10-Pad1_ Net-_D5-Pad2_ Net-_D11-Pad2_ eSim_NPN
R14  Net-_Q12-Pad1_ Net-_D5-Pad2_ 3k
R13  Net-_Q12-Pad2_ Net-_D5-Pad2_ 1.5k
Q12  Net-_Q12-Pad1_ Net-_Q12-Pad2_ Net-_D11-Pad2_ eSim_NPN
Q6  Net-_Q2-Pad2_ Net-_Q6-Pad2_ Net-_D5-Pad2_ eSim_NPN
Q8  Net-_Q6-Pad2_ Net-_D10-Pad1_ Net-_D12-Pad1_ eSim_NPN
D5  Net-_D5-Pad1_ Net-_D5-Pad2_ eSim_Diode
D8  Net-_D10-Pad1_ Net-_D19-Pad2_ eSim_Diode
D2  Net-_D10-Pad1_ Net-_D17-Pad2_ eSim_Diode
D6  Net-_D10-Pad1_ Net-_D18-Pad2_ eSim_Diode
D10  Net-_D10-Pad1_ Net-_D10-Pad2_ eSim_Diode
D18  Net-_D11-Pad2_ Net-_D18-Pad2_ eSim_Diode
D20  Net-_D11-Pad2_ Net-_D10-Pad2_ eSim_Diode
D19  Net-_D11-Pad2_ Net-_D19-Pad2_ eSim_Diode
D17  Net-_D11-Pad2_ Net-_D17-Pad2_ eSim_Diode
U1  Net-_D11-Pad2_ Net-_R1-Pad1_ Net-_D1-Pad2_ Net-_D17-Pad2_ Net-_Q3-Pad3_ Net-_D15-Pad2_ Net-_D18-Pad2_ Net-_Q10-Pad1_ Net-_D14-Pad2_ Net-_D19-Pad2_ Net-_D13-Pad2_ Net-_D10-Pad2_ ? ? PORT
D12  Net-_D12-Pad1_ Net-_D11-Pad2_ eSim_Diode
R2  Net-_R1-Pad1_ Net-_D1-Pad1_ 20k
R1  Net-_R1-Pad1_ Net-_Q4-Pad2_ 10k
R4  Net-_R1-Pad1_ Net-_Q1-Pad2_ 8k
R3  Net-_R1-Pad1_ Net-_Q1-Pad1_ 75
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_D3-Pad1_ eSim_NPN
Q3  Net-_Q1-Pad1_ Net-_D3-Pad1_ Net-_Q3-Pad3_ eSim_NPN
R9  Net-_Q3-Pad3_ Net-_D3-Pad1_ 4.5k
Q9  Net-_Q3-Pad3_ Net-_D3-Pad2_ Net-_D11-Pad2_ eSim_NPN
R11  Net-_Q11-Pad1_ Net-_D3-Pad2_ 3k
R12  Net-_Q11-Pad2_ Net-_D3-Pad2_ 1.5k
Q11  Net-_Q11-Pad1_ Net-_Q11-Pad2_ Net-_D11-Pad2_ eSim_NPN
Q4  Net-_Q1-Pad2_ Net-_Q4-Pad2_ Net-_D3-Pad2_ eSim_NPN
Q7  Net-_Q4-Pad2_ Net-_D1-Pad1_ Net-_D11-Pad1_ eSim_NPN
D3  Net-_D3-Pad1_ Net-_D3-Pad2_ eSim_Diode
D7  Net-_D1-Pad1_ Net-_D14-Pad2_ eSim_Diode
D1  Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
D4  Net-_D1-Pad1_ Net-_D15-Pad2_ eSim_Diode
D9  Net-_D1-Pad1_ Net-_D13-Pad2_ eSim_Diode
D15  Net-_D11-Pad2_ Net-_D15-Pad2_ eSim_Diode
D13  Net-_D11-Pad2_ Net-_D13-Pad2_ eSim_Diode
D14  Net-_D11-Pad2_ Net-_D14-Pad2_ eSim_Diode
D16  Net-_D11-Pad2_ Net-_D1-Pad2_ eSim_Diode
D11  Net-_D11-Pad1_ Net-_D11-Pad2_ eSim_Diode

.end
