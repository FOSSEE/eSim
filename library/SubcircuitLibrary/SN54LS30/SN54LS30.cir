* C:\FOSSEE\eSim\library\SubcircuitLibrary\SN54LS30\SN54LS30.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 02/16/25 17:20:49

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U9  Net-_Q1-Pad2_ Net-_U1-PadOUT_ zener
U10  Net-_Q1-Pad2_ Net-_U10-PadOUT_ zener
U11  Net-_Q1-Pad2_ Net-_U11-PadOUT_ zener
U12  Net-_Q1-Pad2_ Net-_U12-PadOUT_ zener
U13  Net-_Q1-Pad2_ Net-_U13-PadOUT_ zener
U14  Net-_Q1-Pad2_ Net-_U14-PadOUT_ zener
U15  Net-_Q1-Pad2_ Net-_U15-PadOUT_ zener
U16  Net-_Q1-Pad2_ Net-_U16-PadOUT_ zener
U1  GND Net-_U1-PadOUT_ zener
U2  GND Net-_U10-PadOUT_ zener
U3  GND Net-_U11-PadOUT_ zener
U4  GND Net-_U12-PadOUT_ zener
U5  GND Net-_U13-PadOUT_ zener
U6  GND Net-_U14-PadOUT_ zener
U7  GND Net-_U15-PadOUT_ zener
U8  GND Net-_U16-PadOUT_ zener
R1  Net-_R1-Pad1_ Net-_Q1-Pad2_ 17k
R3  Net-_R1-Pad1_ Net-_Q1-Pad1_ 8k
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
Q3  Net-_Q3-Pad1_ Net-_Q1-Pad1_ Net-_Q3-Pad3_ eSim_NPN
U18  Net-_Q3-Pad3_ Net-_Q1-Pad1_ zener
R5  Net-_Q3-Pad3_ Net-_Q4-Pad3_ 4k
U17  Net-_Q4-Pad3_ Net-_Q1-Pad1_ zener
Q4  Net-_Q3-Pad1_ Net-_Q3-Pad3_ Net-_Q4-Pad3_ eSim_NPN
Q5  Net-_Q4-Pad3_ Net-_Q1-Pad3_ GND eSim_NPN
R2  Net-_Q1-Pad3_ Net-_Q2-Pad2_ 1.5k
R4  Net-_Q1-Pad3_ Net-_Q2-Pad1_ 3k
Q2  Net-_Q2-Pad1_ Net-_Q2-Pad2_ GND eSim_NPN
R6  Net-_R1-Pad1_ Net-_Q3-Pad1_ 120
U19  Net-_U1-PadOUT_ Net-_U10-PadOUT_ Net-_U11-PadOUT_ Net-_U12-PadOUT_ Net-_U13-PadOUT_ Net-_U14-PadOUT_ GND Net-_Q4-Pad3_ GND GND Net-_U15-PadOUT_ Net-_U16-PadOUT_ GND Net-_R1-Pad1_ PORT

.end
