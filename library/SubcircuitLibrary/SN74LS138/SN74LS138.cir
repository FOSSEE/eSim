* C:\FOSSEE\eSim\library\SubcircuitLibrary\SN74LS138\SN74LS138.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/18/24 15:20:33

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
X2  Net-_U13-Pad2_ Net-_U14-Pad2_ Net-_U15-Pad2_ Net-_X1-Pad4_ Net-_U19-Pad1_ 4_and
U19  Net-_U19-Pad1_ Net-_U1-Pad7_ d_inverter
X3  Net-_U16-Pad2_ Net-_U14-Pad2_ Net-_U15-Pad2_ Net-_X1-Pad4_ Net-_U20-Pad1_ 4_and
U20  Net-_U20-Pad1_ Net-_U1-Pad8_ d_inverter
X4  Net-_U13-Pad2_ Net-_U17-Pad2_ Net-_U15-Pad2_ Net-_X1-Pad4_ Net-_U21-Pad1_ 4_and
U21  Net-_U21-Pad1_ Net-_U1-Pad9_ d_inverter
X5  Net-_U16-Pad2_ Net-_U17-Pad2_ Net-_U15-Pad2_ Net-_X1-Pad4_ Net-_U22-Pad1_ 4_and
U22  Net-_U22-Pad1_ Net-_U1-Pad10_ d_inverter
X6  Net-_U13-Pad2_ Net-_U14-Pad2_ Net-_U18-Pad2_ Net-_X1-Pad4_ Net-_U23-Pad1_ 4_and
U23  Net-_U23-Pad1_ Net-_U1-Pad11_ d_inverter
X7  Net-_U14-Pad2_ Net-_U18-Pad2_ Net-_U16-Pad2_ Net-_X1-Pad4_ Net-_U24-Pad1_ 4_and
U24  Net-_U24-Pad1_ Net-_U1-Pad12_ d_inverter
X8  Net-_U13-Pad2_ Net-_U18-Pad2_ Net-_U17-Pad2_ Net-_X1-Pad4_ Net-_U25-Pad1_ 4_and
U25  Net-_U25-Pad1_ Net-_U1-Pad13_ d_inverter
X9  Net-_X1-Pad4_ Net-_U17-Pad2_ Net-_U16-Pad2_ Net-_U18-Pad2_ Net-_U26-Pad1_ 4_and
U26  Net-_U26-Pad1_ Net-_U1-Pad14_ d_inverter
U18  Net-_U15-Pad2_ Net-_U18-Pad2_ d_inverter
U17  Net-_U14-Pad2_ Net-_U17-Pad2_ d_inverter
U16  Net-_U13-Pad2_ Net-_U16-Pad2_ d_inverter
X1  Net-_U10-Pad2_ Net-_U11-Pad2_ Net-_U12-Pad2_ Net-_X1-Pad4_ 3_and
U8  Net-_U1-Pad1_ Net-_U10-Pad1_ d_inverter
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ d_inverter
U11  Net-_U1-Pad2_ Net-_U11-Pad2_ d_inverter
U12  Net-_U1-Pad3_ Net-_U12-Pad2_ d_inverter
U13  Net-_U1-Pad4_ Net-_U13-Pad2_ d_inverter
U14  Net-_U1-Pad5_ Net-_U14-Pad2_ d_inverter
U15  Net-_U1-Pad6_ Net-_U15-Pad2_ d_inverter
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ PORT

.end
