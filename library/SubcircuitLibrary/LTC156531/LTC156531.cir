* E:\ESIM\FOSSEE\eSim\library\SubcircuitLibrary\LTC156531\LTC156531.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 05/28/25 21:05:57

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
X1  ? Net-_C1-Pad1_ Net-_C3-Pad1_ Net-_U1-Pad4_ ? Net-_R6-Pad2_ Net-_U1-Pad3_ ? lm_741
R2  Net-_R2-Pad1_ Net-_C3-Pad1_ 350
C3  Net-_C3-Pad1_ GND 0.01u
R6  Net-_C1-Pad1_ Net-_R6-Pad2_ 10k
R4  Net-_C1-Pad1_ GND 10k
C1  Net-_C1-Pad1_ GND 0.0001u
X3  ? Net-_C6-Pad1_ Net-_C7-Pad1_ Net-_U1-Pad4_ ? Net-_C8-Pad1_ Net-_U1-Pad3_ ? lm_741
R8  Net-_R6-Pad2_ Net-_C8-Pad2_ 350
R9  Net-_C8-Pad2_ Net-_C7-Pad1_ 350
C7  Net-_C7-Pad1_ GND 0.01u
C8  Net-_C8-Pad1_ Net-_C8-Pad2_ 0.01u
R11  Net-_C6-Pad1_ Net-_C8-Pad1_ 15.55k
R10  Net-_C6-Pad1_ GND 10k
C6  Net-_C6-Pad1_ GND 0.003u
X4  ? Net-_C9-Pad1_ Net-_C10-Pad1_ Net-_U1-Pad4_ ? Net-_C11-Pad1_ Net-_U1-Pad3_ ? lm_741
R12  Net-_C8-Pad1_ Net-_C11-Pad2_ 350
R13  Net-_C11-Pad2_ Net-_C10-Pad1_ 350
C10  Net-_C10-Pad1_ GND 0.01u
C11  Net-_C11-Pad1_ Net-_C11-Pad2_ 0.01u
R15  Net-_C9-Pad1_ Net-_C11-Pad1_ 7.53k
R14  Net-_C9-Pad1_ GND 10k
C9  Net-_C9-Pad1_ GND 0.005u
X2  ? Net-_C2-Pad1_ Net-_C4-Pad1_ Net-_U1-Pad4_ ? Net-_C5-Pad1_ Net-_U1-Pad3_ ? lm_741
R1  Net-_C11-Pad1_ Net-_C5-Pad2_ 350
R3  Net-_C5-Pad2_ Net-_C4-Pad1_ 350
C4  Net-_C4-Pad1_ GND 0.01u
C5  Net-_C5-Pad1_ Net-_C5-Pad2_ 0.01u
R7  Net-_C2-Pad1_ Net-_C5-Pad1_ 1.98k
R5  Net-_C2-Pad1_ GND 10k
C2  Net-_C2-Pad1_ GND 0.007u
U1  Net-_R2-Pad1_ GND Net-_U1-Pad3_ Net-_U1-Pad4_ GND GND Net-_C5-Pad1_ GND PORT

.end
