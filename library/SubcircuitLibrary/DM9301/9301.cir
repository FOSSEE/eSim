* C:\Users\Public\Music\FOSSEE\eSim\library\SubcircuitLibrary\9301\9301.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 05/24/25 18:09:44

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
X1  Net-_U1-Pad2_ Net-_U2-Pad2_ Net-_U3-Pad2_ Net-_U4-Pad2_ Net-_U9-Pad1_ 4_and
U9  Net-_U9-Pad1_ Net-_U19-Pad13_ d_inverter
X2  Net-_U5-Pad2_ Net-_U2-Pad2_ Net-_U3-Pad2_ Net-_U4-Pad2_ Net-_U10-Pad1_ 4_and
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ d_inverter
X3  Net-_U1-Pad2_ Net-_U6-Pad2_ Net-_U3-Pad2_ Net-_U4-Pad2_ Net-_U11-Pad1_ 4_and
U11  Net-_U11-Pad1_ Net-_U11-Pad2_ d_inverter
X4  Net-_U5-Pad2_ Net-_U6-Pad2_ Net-_U3-Pad2_ Net-_U4-Pad2_ Net-_U12-Pad1_ 4_and
U12  Net-_U12-Pad1_ Net-_U12-Pad2_ d_inverter
X5  Net-_U1-Pad2_ Net-_U2-Pad2_ Net-_X5-Pad3_ Net-_U4-Pad2_ Net-_U13-Pad1_ 4_and
U13  Net-_U13-Pad1_ Net-_U13-Pad2_ d_inverter
X6  Net-_U5-Pad2_ Net-_U2-Pad2_ Net-_X5-Pad3_ Net-_U4-Pad2_ Net-_U14-Pad1_ 4_and
U14  Net-_U14-Pad1_ Net-_U14-Pad2_ d_inverter
X7  Net-_U1-Pad2_ Net-_U6-Pad2_ Net-_U7-Pad2_ Net-_U4-Pad2_ Net-_U15-Pad1_ 4_and
U15  Net-_U15-Pad1_ Net-_U15-Pad2_ d_inverter
X8  Net-_U5-Pad2_ Net-_U6-Pad2_ Net-_X5-Pad3_ Net-_U4-Pad2_ Net-_U16-Pad1_ 4_and
U16  Net-_U16-Pad1_ Net-_U16-Pad2_ d_inverter
X9  Net-_U1-Pad2_ Net-_U2-Pad2_ Net-_U3-Pad2_ Net-_U8-Pad2_ Net-_U17-Pad1_ 4_and
U17  Net-_U17-Pad1_ Net-_U17-Pad2_ d_inverter
X10  Net-_U5-Pad2_ Net-_U2-Pad2_ Net-_U3-Pad2_ Net-_U8-Pad2_ Net-_U18-Pad1_ 4_and
U18  Net-_U18-Pad1_ Net-_U18-Pad2_ d_inverter
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ d_inverter
U5  Net-_U1-Pad2_ Net-_U5-Pad2_ d_inverter
U2  Net-_U19-Pad14_ Net-_U2-Pad2_ d_inverter
U6  Net-_U2-Pad2_ Net-_U6-Pad2_ d_inverter
U3  Net-_U19-Pad1_ Net-_U3-Pad2_ d_inverter
U7  Net-_U3-Pad2_ Net-_U7-Pad2_ d_inverter
U4  Net-_U19-Pad2_ Net-_U4-Pad2_ d_inverter
U8  Net-_U4-Pad2_ Net-_U8-Pad2_ d_inverter
U19  Net-_U19-Pad1_ Net-_U19-Pad2_ Net-_U14-Pad2_ Net-_U15-Pad2_ Net-_U16-Pad2_ Net-_U17-Pad2_ Net-_U18-Pad2_ ? Net-_U13-Pad2_ Net-_U12-Pad2_ Net-_U11-Pad2_ Net-_U10-Pad2_ Net-_U19-Pad13_ Net-_U19-Pad14_ Net-_U1-Pad1_ ? PORT

.end
