.title KiCad schematic
U27 Net-_U23-Pad3_ Net-_U27-Pad2_ Net-_U27-Pad3_ d_nand
U19 Net-_U1-Pad4_ Net-_U19-Pad2_ d_inverter
U23 Net-_U14-Pad3_ Net-_U18-Pad2_ Net-_U23-Pad3_ d_nand
U15 Net-_U10-Pad2_ Net-_U15-Pad2_ Net-_U15-Pad3_ d_or
U22 Net-_U19-Pad2_ Net-_U15-Pad3_ Net-_U22-Pad3_ d_nand
U26 Net-_U26-Pad1_ Net-_U22-Pad3_ Net-_U26-Pad3_ d_nand
U1 Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ GND Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ GND PORT
U14 Net-_U14-Pad1_ Net-_U14-Pad2_ Net-_U14-Pad3_ d_or
U18 Net-_U1-Pad1_ Net-_U18-Pad2_ d_inverter
U10 Net-_U10-Pad1_ Net-_U10-Pad2_ d_inverter
U9 Net-_U27-Pad2_ Net-_U15-Pad2_ d_inverter
U37 Net-_U29-Pad3_ Net-_U37-Pad2_ d_inverter
U29 Net-_U25-Pad3_ Net-_U29-Pad2_ Net-_U29-Pad3_ d_nand
U20 Net-_U1-Pad13_ Net-_U20-Pad2_ d_inverter
U25 Net-_U16-Pad3_ Net-_U20-Pad2_ Net-_U25-Pad3_ d_nand
U21 Net-_U1-Pad10_ Net-_U21-Pad2_ d_inverter
U24 Net-_U21-Pad2_ Net-_U17-Pad3_ Net-_U24-Pad3_ d_nand
U28 Net-_U28-Pad1_ Net-_U24-Pad3_ Net-_U28-Pad3_ d_nand
U42 Net-_U1-Pad13_ Net-_U42-Pad2_ d_inverter
U35 Net-_U1-Pad13_ Net-_U35-Pad2_ d_inverter
U34 Net-_U28-Pad3_ Net-_U34-Pad2_ d_inverter
U43 Net-_U34-Pad2_ Net-_U35-Pad2_ Net-_U43-Pad3_ d_or
U51 Net-_U42-Pad2_ Net-_U51-Pad2_ d_inverter
U40 Net-_U30-Pad2_ Net-_U31-Pad2_ Net-_U40-Pad3_ d_or
U31 Net-_U1-Pad1_ Net-_U31-Pad2_ d_inverter
U39 Net-_U1-Pad1_ Net-_U39-Pad2_ d_inverter
U41 Net-_U1-Pad10_ Net-_U41-Pad2_ d_inverter
U36 Net-_U1-Pad10_ Net-_U36-Pad2_ d_inverter
U32 Net-_U1-Pad4_ Net-_U32-Pad2_ d_inverter
U49 Net-_U38-Pad2_ Net-_U49-Pad2_ d_inverter
U38 Net-_U1-Pad4_ Net-_U38-Pad2_ d_inverter
U30 Net-_U26-Pad3_ Net-_U30-Pad2_ d_inverter
U33 Net-_U27-Pad3_ Net-_U33-Pad2_ d_inverter
U16 Net-_U16-Pad1_ Net-_U11-Pad1_ Net-_U16-Pad3_ d_or
U7 Net-_U3-Pad2_ Net-_U11-Pad1_ d_inverter
U17 Net-_U13-Pad2_ Net-_U12-Pad2_ Net-_U17-Pad3_ d_or
U13 Net-_U11-Pad2_ Net-_U13-Pad2_ d_inverter
U11 Net-_U11-Pad1_ Net-_U11-Pad2_ d_inverter
U12 Net-_U29-Pad2_ Net-_U12-Pad2_ d_inverter
U3 Net-_U1-Pad12_ Net-_U3-Pad2_ d_inverter
U6 Net-_U28-Pad1_ Net-_U16-Pad1_ d_inverter
U4 Net-_U26-Pad1_ Net-_U14-Pad1_ d_inverter
U5 Net-_U2-Pad2_ Net-_U14-Pad2_ d_inverter
U2 Net-_U1-Pad2_ Net-_U2-Pad2_ d_inverter
U8 Net-_U14-Pad2_ Net-_U10-Pad1_ d_inverter
U46 Net-_U1-Pad3_ Net-_U40-Pad3_ Net-_U27-Pad2_ d_nand
U44 Net-_U32-Pad2_ Net-_U33-Pad2_ Net-_U44-Pad3_ d_or
U48 Net-_U39-Pad2_ Net-_U48-Pad2_ d_inverter
U60 Net-_U49-Pad2_ Net-_U60-Pad2_ d_inverter
U50 Net-_U44-Pad3_ Net-_U1-Pad3_ Net-_U26-Pad1_ d_nand
U56 Net-_U48-Pad2_ Net-_U56-Pad2_ d_inverter
U55 Net-_U27-Pad2_ Net-_U55-Pad2_ d_inverter
U54 Net-_U54-Pad1_ Net-_U54-Pad2_ d_inverter
U67 Net-_U60-Pad2_ Net-_U61-Pad2_ Net-_U67-Pad3_ d_or
U62 Net-_U62-Pad1_ Net-_U62-Pad2_ d_inverter
U66 Net-_U54-Pad2_ Net-_U55-Pad2_ Net-_U66-Pad3_ d_or
U71 Net-_U67-Pad3_ Net-_U62-Pad2_ Net-_U54-Pad1_ d_or
U61 Net-_U26-Pad1_ Net-_U61-Pad2_ d_inverter
U80 Net-_U76-Pad2_ Net-_U1-Pad8_ d_inverter
U81 Net-_U77-Pad2_ Net-_U1-Pad9_ d_inverter
U59 Net-_U51-Pad2_ Net-_U59-Pad2_ d_inverter
U77 Net-_U57-Pad1_ Net-_U77-Pad2_ d_inverter
U73 Net-_U69-Pad3_ Net-_U65-Pad2_ Net-_U57-Pad1_ d_or
U72 Net-_U68-Pad3_ Net-_U59-Pad2_ Net-_U65-Pad1_ d_or
U76 Net-_U65-Pad1_ Net-_U76-Pad2_ d_inverter
U69 Net-_U63-Pad2_ Net-_U64-Pad2_ Net-_U69-Pad3_ d_or
U58 Net-_U29-Pad2_ Net-_U58-Pad2_ d_inverter
U57 Net-_U57-Pad1_ Net-_U57-Pad2_ d_inverter
U45 Net-_U36-Pad2_ Net-_U37-Pad2_ Net-_U45-Pad3_ d_or
U65 Net-_U65-Pad1_ Net-_U65-Pad2_ d_inverter
U64 Net-_U28-Pad1_ Net-_U64-Pad2_ d_inverter
U53 Net-_U45-Pad3_ Net-_U1-Pad11_ Net-_U28-Pad1_ d_nand
U63 Net-_U52-Pad2_ Net-_U63-Pad2_ d_inverter
U52 Net-_U41-Pad2_ Net-_U52-Pad2_ d_inverter
U68 Net-_U57-Pad2_ Net-_U58-Pad2_ Net-_U68-Pad3_ d_or
U47 Net-_U1-Pad11_ Net-_U43-Pad3_ Net-_U29-Pad2_ d_nand
U79 Net-_U75-Pad2_ Net-_U1-Pad5_ d_inverter
U75 Net-_U54-Pad1_ Net-_U75-Pad2_ d_inverter
U74 Net-_U62-Pad1_ Net-_U74-Pad2_ d_inverter
U78 Net-_U74-Pad2_ Net-_U1-Pad6_ d_inverter
U70 Net-_U66-Pad3_ Net-_U56-Pad2_ Net-_U62-Pad1_ d_or
.end
