* C:\Users\HP\OneDrive\Documents\FOSSEE\eSim\library\SubcircuitLibrary\NJU7031\NJU7031.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/08/25 16:44:58

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
M5  /VDD Net-_M12-Pad1_ Net-_M12-Pad1_ /VDD mosfet_p
M6  /VDD Net-_M12-Pad1_ Net-_M12-Pad2_ /VDD mosfet_p
M12  Net-_M12-Pad1_ Net-_M12-Pad2_ Net-_M12-Pad3_ Net-_M12-Pad3_ mosfet_n
M13  Net-_M12-Pad2_ Net-_M12-Pad2_ /VSS /VSS mosfet_n
R1  Net-_R1-Pad1_ Net-_M12-Pad3_ 100k
R2  Net-_R2-Pad1_ Net-_R1-Pad1_ 200k
R5  /VSS Net-_R2-Pad1_ 100k
M3  /VDD Net-_M12-Pad1_ Net-_M10-Pad1_ /VDD mosfet_p
M10  Net-_M10-Pad1_ Net-_M10-Pad1_ /VSS /VSS mosfet_n
M11  Net-_M10-Pad1_ Net-_C1-Pad2_ /VSS /VSS mosfet_n
M4  /VDD Net-_M12-Pad1_ Net-_M4-Pad3_ /VDD mosfet_p
M7  Net-_M4-Pad3_ /INV Net-_D1-Pad2_ /VDD mosfet_p
M8  Net-_M4-Pad3_ /NON_INV Net-_C1-Pad2_ /VDD mosfet_p
M15  Net-_D1-Pad2_ Net-_D1-Pad2_ /OFFSET_NULL_IN1 /VSS mosfet_n
M16  Net-_C1-Pad2_ Net-_D1-Pad2_ /OFFSET_NULL_INV2 /VSS mosfet_n
R3  /VSS /OFFSET_NULL_IN1 3k
R4  /VSS /OFFSET_NULL_INV2 3k
D1  /VSS Net-_D1-Pad2_ eSim_Diode
D2  /VSS Net-_C1-Pad2_ eSim_Diode
M1  /VDD Net-_M1-Pad2_ Net-_M1-Pad2_ /VDD mosfet_p
M2  /VDD Net-_M1-Pad2_ /OUT /VDD mosfet_p
M9  Net-_M1-Pad2_ Net-_M10-Pad1_ /VSS /VSS mosfet_n
M14  /OUT Net-_C1-Pad2_ /VSS /VSS mosfet_n
C1  /OUT Net-_C1-Pad2_ 30p
U1  /VDD /INV /NON_INV /OUT /OFFSET_NULL_IN1 /OFFSET_NULL_INV2 /VSS ? PORT

.end
