* C:\FOSSEE\eSim\library\SubcircuitLibrary\SN5410\SN5410.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 02/18/25 22:45:04

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_D1-Pad2_ eSim_NPN
Q2  Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_D2-Pad2_ eSim_NPN
Q3  Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_D3-Pad2_ eSim_NPN
D1  GND Net-_D1-Pad2_ eSim_Diode
D3  GND Net-_D3-Pad2_ eSim_Diode
D2  GND Net-_D2-Pad2_ eSim_Diode
Q4  Net-_Q4-Pad1_ Net-_Q1-Pad1_ Net-_Q4-Pad3_ eSim_NPN
R1  Net-_R1-Pad1_ Net-_Q1-Pad2_ 4k
R3  Net-_R1-Pad1_ Net-_Q4-Pad1_ 1.6k
Q5  Net-_Q5-Pad1_ Net-_Q4-Pad1_ Net-_D5-Pad1_ eSim_NPN
R4  Net-_R1-Pad1_ Net-_Q5-Pad1_ 130
D5  Net-_D5-Pad1_ Net-_D5-Pad2_ eSim_Diode
Q6  Net-_D5-Pad2_ Net-_Q4-Pad3_ GND eSim_NPN
R2  Net-_Q4-Pad3_ GND 1k
Q13  Net-_Q13-Pad1_ Net-_Q13-Pad2_ Net-_D9-Pad2_ eSim_NPN
Q14  Net-_Q13-Pad1_ Net-_Q13-Pad2_ Net-_D10-Pad2_ eSim_NPN
Q15  Net-_Q13-Pad1_ Net-_Q13-Pad2_ Net-_D11-Pad2_ eSim_NPN
D9  GND Net-_D9-Pad2_ eSim_Diode
D11  GND Net-_D11-Pad2_ eSim_Diode
D10  GND Net-_D10-Pad2_ eSim_Diode
Q16  Net-_Q16-Pad1_ Net-_Q13-Pad1_ Net-_Q16-Pad3_ eSim_NPN
R9  Net-_R1-Pad1_ Net-_Q13-Pad2_ 4k
R11  Net-_R1-Pad1_ Net-_Q16-Pad1_ 1.6k
Q17  Net-_Q17-Pad1_ Net-_Q16-Pad1_ Net-_D12-Pad1_ eSim_NPN
R12  Net-_R1-Pad1_ Net-_Q17-Pad1_ 130
D12  Net-_D12-Pad1_ Net-_D12-Pad2_ eSim_Diode
Q18  Net-_D12-Pad2_ Net-_Q16-Pad3_ GND eSim_NPN
R10  Net-_Q16-Pad3_ GND 1k
Q7  Net-_Q10-Pad2_ Net-_Q7-Pad2_ Net-_D4-Pad2_ eSim_NPN
Q8  Net-_Q10-Pad2_ Net-_Q7-Pad2_ Net-_D6-Pad2_ eSim_NPN
Q9  Net-_Q10-Pad2_ Net-_Q7-Pad2_ Net-_D7-Pad2_ eSim_NPN
D4  GND Net-_D4-Pad2_ eSim_Diode
D7  GND Net-_D7-Pad2_ eSim_Diode
D6  GND Net-_D6-Pad2_ eSim_Diode
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
R5  Net-_R1-Pad1_ Net-_Q7-Pad2_ 4k
R7  Net-_R1-Pad1_ Net-_Q10-Pad1_ 1.6k
Q11  Net-_Q11-Pad1_ Net-_Q10-Pad1_ Net-_D8-Pad1_ eSim_NPN
R8  Net-_R1-Pad1_ Net-_Q11-Pad1_ 130
D8  Net-_D8-Pad1_ Net-_D8-Pad2_ eSim_Diode
Q12  Net-_D8-Pad2_ Net-_Q10-Pad3_ GND eSim_NPN
R6  Net-_Q10-Pad3_ GND 1k
U1  Net-_D1-Pad2_ Net-_D2-Pad2_ Net-_D4-Pad2_ Net-_D6-Pad2_ Net-_D7-Pad2_ Net-_D8-Pad2_ GND Net-_D12-Pad2_ Net-_D9-Pad2_ Net-_D10-Pad2_ Net-_D11-Pad2_ Net-_D5-Pad2_ Net-_D3-Pad2_ Net-_R1-Pad1_ PORT

.end
