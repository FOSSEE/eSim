* C:\FOSSEE\eSim\library\SubcircuitLibrary\IC_LM833\IC_LM833.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 03/14/23 13:41:34

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U2  Net-_Q2-Pad2_ Net-_Q5-Pad2_ Net-_D4-Pad1_ Net-_Q14-Pad2_ Net-_Q17-Pad2_ Net-_C1-Pad2_ Net-_D1-Pad1_ Net-_D8-Pad1_ PORT
C3  Net-_C3-Pad1_ Net-_C2-Pad2_ 1n
C2  Net-_C2-Pad1_ Net-_C2-Pad2_ 1n
R3  Net-_D1-Pad1_ Net-_Q3-Pad3_ 5k
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 1n
R6  Net-_Q11-Pad3_ Net-_C1-Pad2_ 2k
Q12  Net-_D3-Pad1_ Net-_Q10-Pad3_ Net-_D4-Pad1_ eSim_NPN
R8  Net-_D4-Pad1_ Net-_Q10-Pad3_ 2k
Q11  Net-_D4-Pad1_ Net-_C3-Pad1_ Net-_Q11-Pad3_ eSim_NPN
Q10  Net-_D1-Pad1_ Net-_D3-Pad1_ Net-_Q10-Pad3_ eSim_NPN
R7  Net-_D3-Pad2_ Net-_Q10-Pad3_ 1k
D4  Net-_D4-Pad1_ Net-_D3-Pad2_ eSim_Diode
D3  Net-_D3-Pad1_ Net-_D3-Pad2_ eSim_Diode
Q9  Net-_D3-Pad2_ Net-_C3-Pad1_ Net-_Q11-Pad3_ eSim_NPN
Q8  Net-_D3-Pad1_ Net-_D1-Pad2_ Net-_D1-Pad1_ eSim_PNP
Q6  Net-_C2-Pad1_ Net-_Q11-Pad3_ Net-_C1-Pad2_ eSim_NPN
R5  Net-_C3-Pad1_ Net-_Q11-Pad3_ 2k
R4  Net-_Q4-Pad3_ Net-_C1-Pad2_ 5k
R2  Net-_C1-Pad1_ Net-_C1-Pad2_ 2k
R1  Net-_Q1-Pad3_ Net-_C1-Pad2_ 5k
D1  Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
Q3  Net-_Q2-Pad3_ Net-_D1-Pad2_ Net-_Q3-Pad3_ eSim_PNP
D2  Net-_D2-Pad1_ Net-_C1-Pad1_ eSim_Diode
Q7  Net-_D3-Pad1_ Net-_C2-Pad1_ Net-_C3-Pad1_ eSim_NPN
Q4  Net-_C2-Pad1_ Net-_D2-Pad1_ Net-_Q4-Pad3_ eSim_NPN
Q5  Net-_C2-Pad1_ Net-_Q5-Pad2_ Net-_Q2-Pad3_ eSim_PNP
Q2  Net-_D2-Pad1_ Net-_Q2-Pad2_ Net-_Q2-Pad3_ eSim_PNP
Q1  Net-_D1-Pad2_ Net-_M1-Pad3_ Net-_Q1-Pad3_ eSim_NPN
U1  Net-_C1-Pad2_ Net-_M1-Pad3_ zener
M1  Net-_D1-Pad1_ Net-_C1-Pad2_ Net-_M1-Pad3_ Net-_D1-Pad1_ mosfet_p
C6  Net-_C6-Pad1_ Net-_C5-Pad2_ 1n
C5  Net-_C5-Pad1_ Net-_C5-Pad2_ 1n
R11  Net-_D1-Pad1_ Net-_Q15-Pad3_ 5k
C4  Net-_C4-Pad1_ Net-_C1-Pad2_ 1n
R14  Net-_Q18-Pad2_ Net-_C1-Pad2_ 2k
Q24  Net-_D7-Pad1_ Net-_Q22-Pad3_ Net-_D8-Pad1_ eSim_NPN
R16  Net-_D8-Pad1_ Net-_Q22-Pad3_ 2k
Q23  Net-_D8-Pad1_ Net-_C6-Pad1_ Net-_Q18-Pad2_ eSim_NPN
Q22  Net-_D1-Pad1_ Net-_D7-Pad1_ Net-_Q22-Pad3_ eSim_NPN
R15  Net-_D7-Pad2_ Net-_Q22-Pad3_ 1k
D8  Net-_D8-Pad1_ Net-_D7-Pad2_ eSim_Diode
D7  Net-_D7-Pad1_ Net-_D7-Pad2_ eSim_Diode
Q21  Net-_D7-Pad2_ Net-_C6-Pad1_ Net-_Q18-Pad2_ eSim_NPN
Q20  Net-_D7-Pad1_ Net-_D5-Pad2_ Net-_D1-Pad1_ eSim_PNP
Q18  Net-_C5-Pad1_ Net-_Q18-Pad2_ Net-_C1-Pad2_ eSim_NPN
R13  Net-_C6-Pad1_ Net-_Q18-Pad2_ 2k
R12  Net-_Q16-Pad3_ Net-_C1-Pad2_ 5k
R10  Net-_C4-Pad1_ Net-_C1-Pad2_ 2k
R9  Net-_Q13-Pad3_ Net-_C1-Pad2_ 5k
D5  Net-_D1-Pad1_ Net-_D5-Pad2_ eSim_Diode
Q15  Net-_Q14-Pad3_ Net-_D5-Pad2_ Net-_Q15-Pad3_ eSim_PNP
D6  Net-_D6-Pad1_ Net-_C4-Pad1_ eSim_Diode
Q19  Net-_D7-Pad1_ Net-_C5-Pad1_ Net-_C6-Pad1_ eSim_NPN
Q16  Net-_C5-Pad1_ Net-_D6-Pad1_ Net-_Q16-Pad3_ eSim_NPN
Q17  Net-_C5-Pad1_ Net-_Q17-Pad2_ Net-_Q14-Pad3_ eSim_PNP
Q14  Net-_D6-Pad1_ Net-_Q14-Pad2_ Net-_Q14-Pad3_ eSim_PNP
Q13  Net-_D5-Pad2_ Net-_M2-Pad3_ Net-_Q13-Pad3_ eSim_NPN
U3  Net-_C1-Pad2_ Net-_M2-Pad3_ zener
M2  Net-_D1-Pad1_ Net-_C1-Pad2_ Net-_M2-Pad3_ Net-_D1-Pad1_ mosfet_p

.end
