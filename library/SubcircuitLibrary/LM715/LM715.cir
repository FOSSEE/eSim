.title KiCad schematic
Q17 Net-_Q14-Pad1_ Net-_C1-Pad2_ Net-_Q17-Pad3_ eSim_NPN
R24 Net-_Q17-Pad3_ Net-_Q21-Pad1_ 3k
R23 Net-_Q16-Pad3_ Net-_Q21-Pad1_ 300
Q16 Net-_C1-Pad2_ Net-_Q16-Pad2_ Net-_Q16-Pad3_ eSim_NPN
Q21 Net-_Q21-Pad1_ Net-_Q19-Pad3_ Net-_C1-Pad2_ eSim_PNP
Q23 Net-_Q21-Pad1_ Net-_Q19-Pad3_ Net-_Q23-Pad3_ eSim_PNP
R25 Net-_Q20-Pad3_ Net-_Q21-Pad1_ 75
Q20 Net-_Q19-Pad3_ Net-_Q17-Pad3_ Net-_Q20-Pad3_ eSim_NPN
U1 Net-_Q10-Pad2_ Net-_Q12-Pad2_ Net-_R1-Pad1_ Net-_R20-Pad1_ Net-_Q21-Pad1_ Net-_R27-Pad2_ Net-_R11-Pad2_ Net-_Q14-Pad1_ Net-_Q10-Pad1_ Net-_R2-Pad1_ PORT
Q15 Net-_Q14-Pad1_ Net-_Q14-Pad3_ Net-_C1-Pad1_ eSim_NPN
Q14 Net-_Q14-Pad1_ Net-_Q14-Pad2_ Net-_Q14-Pad3_ eSim_NPN
C1 Net-_C1-Pad1_ Net-_C1-Pad2_ 15p
R22 Net-_C1-Pad1_ Net-_C1-Pad2_ 25k
R21 Net-_C1-Pad1_ Net-_Q14-Pad3_ 1k
Q7 Net-_Q6-Pad2_ Net-_Q16-Pad2_ Net-_Q7-Pad3_ eSim_NPN
Q5 Net-_Q16-Pad2_ Net-_Q16-Pad2_ Net-_Q5-Pad3_ eSim_NPN
R8 Net-_Q9-Pad1_ Net-_Q4-Pad3_ 100
R6 Net-_Q5-Pad3_ Net-_Q21-Pad1_ 2k
R9 Net-_Q7-Pad3_ Net-_Q21-Pad1_ 300
Q3 Net-_Q3-Pad1_ Net-_Q12-Pad2_ Net-_Q1-Pad1_ eSim_NPN
R4 Net-_Q4-Pad3_ Net-_Q1-Pad3_ 10k
Q1 Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
R1 Net-_R1-Pad1_ Net-_Q1-Pad2_ 300
R2 Net-_R2-Pad1_ Net-_Q3-Pad1_ 300
Q6 Net-_Q12-Pad2_ Net-_Q6-Pad2_ Net-_Q16-Pad2_ eSim_NPN
Q4 Net-_Q1-Pad1_ Net-_Q1-Pad3_ Net-_Q4-Pad3_ eSim_NPN
R3 Net-_Q3-Pad1_ Net-_Q2-Pad3_ 6k
Q2 Net-_Q14-Pad1_ Net-_Q2-Pad2_ Net-_Q2-Pad3_ eSim_NPN
R7 Net-_Q2-Pad2_ Net-_Q14-Pad1_ 10k
R10 Net-_Q14-Pad2_ Net-_Q14-Pad1_ 4k
R11 Net-_Q14-Pad2_ Net-_R11-Pad2_ 100
R17 Net-_Q10-Pad1_ Net-_Q14-Pad1_ 4k
R5 Net-_Q2-Pad2_ Net-_Q12-Pad2_ 15k
R26 Net-_Q18-Pad1_ Net-_Q14-Pad1_ 10k
Q18 Net-_Q18-Pad1_ Net-_Q18-Pad1_ Net-_Q18-Pad3_ eSim_NPN
Q19 Net-_Q18-Pad3_ Net-_Q18-Pad3_ Net-_Q19-Pad3_ eSim_NPN
R28 Net-_R27-Pad2_ Net-_Q23-Pad3_ 300
Q22 Net-_Q14-Pad1_ Net-_Q18-Pad1_ Net-_Q22-Pad3_ eSim_NPN
R27 Net-_Q22-Pad3_ Net-_R27-Pad2_ 300
R19 Net-_Q10-Pad2_ Net-_Q2-Pad3_ 6k
Q10 Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
R12 Net-_Q8-Pad3_ Net-_R12-Pad2_ 50
R15 Net-_R12-Pad2_ Net-_Q10-Pad3_ 50
Q8 Net-_Q14-Pad2_ Net-_Q3-Pad1_ Net-_Q8-Pad3_ eSim_NPN
Q12 Net-_Q10-Pad2_ Net-_Q12-Pad2_ Net-_Q11-Pad1_ eSim_NPN
R20 Net-_R20-Pad1_ Net-_Q13-Pad2_ 400
R18 Net-_Q11-Pad2_ Net-_Q11-Pad3_ 10k
Q13 Net-_Q11-Pad1_ Net-_Q13-Pad2_ Net-_Q11-Pad2_ eSim_NPN
Q11 Net-_Q11-Pad1_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_NPN
R14 Net-_Q6-Pad2_ Net-_R12-Pad2_ 25k
R16 Net-_Q11-Pad3_ Net-_Q9-Pad1_ 100
R13 Net-_Q9-Pad3_ Net-_Q21-Pad1_ 500
Q9 Net-_Q9-Pad1_ Net-_Q16-Pad2_ Net-_Q9-Pad3_ eSim_NPN
.end
