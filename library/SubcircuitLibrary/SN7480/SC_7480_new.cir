* C:\FOSSEE2\eSim\library\SubcircuitLibrary\SC_7480_new\SC_7480_new.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 05/28/25 13:19:54

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U2  Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U2-Pad3_ d_nand
U4  Net-_U2-Pad3_ Net-_U1-Pad10_ Net-_U4-Pad3_ d_and
U15  Net-_U10-Pad3_ Net-_U1-Pad4_ Net-_U15-Pad3_ d_and
U16  Net-_U1-Pad4_ Net-_U11-Pad3_ Net-_U16-Pad3_ d_and
U17  Net-_U1-Pad4_ Net-_U1-Pad3_ Net-_U17-Pad3_ d_and
X2  Net-_U15-Pad3_ Net-_U16-Pad3_ Net-_U17-Pad3_ Net-_X1-Pad4_ Net-_U18-Pad1_ 4_OR
U18  Net-_U18-Pad1_ Net-_U1-Pad6_ d_inverter
U20  Net-_U1-Pad6_ Net-_U1-Pad5_ d_inverter
U12  Net-_U1-Pad3_ Net-_U10-Pad3_ Net-_U12-Pad3_ d_and
U13  Net-_U1-Pad3_ Net-_U11-Pad3_ Net-_U13-Pad3_ d_and
U14  Net-_U11-Pad3_ Net-_U10-Pad3_ Net-_U14-Pad3_ d_and
X3  Net-_U12-Pad3_ Net-_U13-Pad3_ Net-_U14-Pad3_ ? Net-_U19-Pad1_ 4_OR
U19  Net-_U19-Pad1_ Net-_U1-Pad4_ d_inverter
U3  Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U3-Pad3_ d_nand
U5  Net-_U3-Pad3_ Net-_U1-Pad1_ Net-_U5-Pad3_ d_and
X1  Net-_U11-Pad3_ Net-_U10-Pad3_ Net-_U1-Pad3_ Net-_X1-Pad4_ 3_and
U7  Net-_U1-Pad11_ Net-_U10-Pad2_ d_inverter
U9  Net-_U5-Pad3_ Net-_U11-Pad1_ d_inverter
U6  Net-_U1-Pad2_ Net-_U11-Pad2_ d_inverter
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ Net-_U10-Pad3_ d_or
U11  Net-_U11-Pad1_ Net-_U11-Pad2_ Net-_U11-Pad3_ d_or
U8  Net-_U4-Pad3_ Net-_U10-Pad1_ d_inverter
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ ? Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ ? PORT

.end
