* C:\Users\senba\Desktop\FOSSEE\eSim\library\SubcircuitLibrary\SN74155\SN74155.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 11/29/25 17:44:33

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U11  Net-_U11-Pad1_ Net-_U11-Pad2_ Net-_U11-Pad3_ d_and
U2  Net-_U1-Pad2_ Net-_U2-Pad2_ d_inverter
U3  Net-_U1-Pad3_ Net-_U3-Pad2_ d_inverter
U5  Net-_U1-Pad1_ Net-_U11-Pad1_ d_inverter
U6  Net-_U2-Pad2_ Net-_U11-Pad2_ d_inverter
U9  Net-_U3-Pad2_ Net-_U9-Pad2_ d_inverter
U4  Net-_U1-Pad4_ Net-_U10-Pad1_ d_inverter
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ d_inverter
U7  Net-_U1-Pad2_ Net-_U12-Pad1_ d_inverter
U8  Net-_U1-Pad1_ Net-_U12-Pad2_ d_inverter
U12  Net-_U12-Pad1_ Net-_U12-Pad2_ Net-_U12-Pad3_ d_and
X2  Net-_U3-Pad2_ Net-_U10-Pad1_ Net-_U11-Pad3_ Net-_U14-Pad1_ 3_and
X3  Net-_U3-Pad2_ Net-_U10-Pad2_ Net-_U11-Pad3_ Net-_U15-Pad1_ 3_and
X4  Net-_U9-Pad2_ Net-_U10-Pad1_ Net-_U11-Pad3_ Net-_U16-Pad1_ 3_and
X5  Net-_U9-Pad2_ Net-_U10-Pad2_ Net-_U11-Pad3_ Net-_U17-Pad1_ 3_and
X6  Net-_U3-Pad2_ Net-_U10-Pad1_ Net-_U12-Pad3_ Net-_U18-Pad1_ 3_and
X7  Net-_U3-Pad2_ Net-_U10-Pad2_ Net-_U12-Pad3_ Net-_U19-Pad1_ 3_and
X8  Net-_U9-Pad2_ Net-_U10-Pad1_ Net-_U12-Pad3_ Net-_U20-Pad1_ 3_and
X1  Net-_U9-Pad2_ Net-_U10-Pad2_ Net-_U12-Pad3_ Net-_U13-Pad1_ 3_and
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ PORT
U14  Net-_U14-Pad1_ Net-_U1-Pad5_ d_inverter
U15  Net-_U15-Pad1_ Net-_U1-Pad6_ d_inverter
U16  Net-_U16-Pad1_ Net-_U1-Pad7_ d_inverter
U17  Net-_U17-Pad1_ Net-_U1-Pad8_ d_inverter
U18  Net-_U18-Pad1_ Net-_U1-Pad9_ d_inverter
U19  Net-_U19-Pad1_ Net-_U1-Pad10_ d_inverter
U20  Net-_U20-Pad1_ Net-_U1-Pad11_ d_inverter
U13  Net-_U13-Pad1_ Net-_U1-Pad12_ d_inverter

.end
