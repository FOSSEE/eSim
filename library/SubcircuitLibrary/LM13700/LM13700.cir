* C:\Users\Chaithu\FOSSEE\eSim\library\SubcircuitLibrary\LM13700\LM13700.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 5/22/2025 8:57:58 AM

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
Q1  Net-_Q1-Pad1_ /INPUT_-_ Net-_Q1-Pad3_ eSim_NPN
Q5  Net-_Q5-Pad1_ /INPUT_+_ Net-_Q1-Pad3_ eSim_NPN
D1  /DIODEBIAS /INPUT_-_ eSim_Diode
Q4  Net-_Q1-Pad3_ /AMPBIASINPUT Net-_D2-Pad1_ eSim_NPN
Q2  /AMPBIASINPUT Net-_D2-Pad1_ /V_-_ eSim_NPN
D2  Net-_D2-Pad1_ /V_-_ eSim_Diode
D4  /DIODEBIAS /INPUT_+_ eSim_Diode
Q3  Net-_Q1-Pad1_ Net-_D3-Pad2_ /V_+_ eSim_PNP
Q6  Net-_Q10-Pad2_ Net-_Q1-Pad1_ Net-_D3-Pad2_ eSim_PNP
D3  /V_+_ Net-_D3-Pad2_ eSim_Diode
Q8  Net-_Q10-Pad2_ Net-_D6-Pad1_ /V_-_ eSim_NPN
Q10  /OUTPUT Net-_Q10-Pad2_ Net-_D6-Pad1_ eSim_NPN
D6  Net-_D6-Pad1_ /V_-_ eSim_Diode
Q9  /OUTPUT Net-_Q5-Pad1_ Net-_D5-Pad2_ eSim_PNP
Q7  Net-_Q5-Pad1_ Net-_D5-Pad2_ /V_+_ eSim_PNP
D5  /V_+_ Net-_D5-Pad2_ eSim_Diode
Q11  Net-_Q11-Pad1_ /INPUT2_-_ Net-_Q11-Pad3_ eSim_NPN
Q15  Net-_Q15-Pad1_ /INPUT2_+_ Net-_Q11-Pad3_ eSim_NPN
D7  /DIODEBIAS2 /INPUT2_-_ eSim_Diode
Q14  Net-_Q11-Pad3_ /AMPBIASINPUT2 Net-_D8-Pad1_ eSim_NPN
Q12  /AMPBIASINPUT2 Net-_D8-Pad1_ /V_-_ eSim_NPN
D8  Net-_D8-Pad1_ /V_-_ eSim_Diode
D10  /DIODEBIAS2 /INPUT2_+_ eSim_Diode
Q13  Net-_Q11-Pad1_ Net-_D9-Pad2_ /V_+_ eSim_PNP
Q16  Net-_Q16-Pad1_ Net-_Q11-Pad1_ Net-_D9-Pad2_ eSim_PNP
D9  /V_+_ Net-_D9-Pad2_ eSim_Diode
Q18  Net-_Q16-Pad1_ Net-_D12-Pad1_ /V_-_ eSim_NPN
Q20  /OUTPUT2 Net-_Q16-Pad1_ Net-_D12-Pad1_ eSim_NPN
D12  Net-_D12-Pad1_ /V_-_ eSim_Diode
Q19  /OUTPUT2 Net-_Q15-Pad1_ Net-_D11-Pad2_ eSim_PNP
Q17  Net-_Q15-Pad1_ Net-_D11-Pad2_ /V_+_ eSim_PNP
D11  /V_+_ Net-_D11-Pad2_ eSim_Diode
U1  /DIODEBIAS /INPUT_-_ /V_+_ /V_-_ /AMPBIASINPUT /INPUT_+_ /DIODEBIAS2 /INPUT2_-_ /OUTPUT /AMPBIASINPUT2 /INPUT2_+_ /OUTPUT2 PORT

.end
