* D:\FOSSEE\eSim\library\SubcircuitLibrary\MM54C42\MM54C42.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 07/17/25 20:49:57

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U4  Net-_U39-Pad15_ Net-_U4-Pad2_ d_inverter
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ d_inverter
U2  Net-_U11-Pad1_ Net-_U10-Pad1_ d_inverter
U3  Net-_U10-Pad2_ Net-_U11-Pad2_ d_inverter
U7  Net-_U39-Pad15_ Net-_U1-Pad2_ Net-_U12-Pad1_ d_and
U6  Net-_U4-Pad2_ Net-_U1-Pad1_ Net-_U17-Pad1_ d_and
U8  Net-_U1-Pad2_ Net-_U4-Pad2_ Net-_U13-Pad1_ d_and
U5  Net-_U39-Pad15_ Net-_U1-Pad1_ Net-_U18-Pad1_ d_and
U11  Net-_U11-Pad1_ Net-_U11-Pad2_ Net-_U11-Pad3_ d_and
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ Net-_U10-Pad3_ d_and
U9  Net-_U10-Pad1_ Net-_U11-Pad2_ Net-_U14-Pad1_ d_and
U18  Net-_U18-Pad1_ Net-_U18-Pad2_ d_inverter
U12  Net-_U12-Pad1_ Net-_U12-Pad2_ d_inverter
U17  Net-_U17-Pad1_ Net-_U17-Pad2_ d_inverter
U13  Net-_U13-Pad1_ Net-_U13-Pad2_ d_inverter
U14  Net-_U14-Pad1_ Net-_U14-Pad2_ d_inverter
U15  Net-_U11-Pad3_ Net-_U15-Pad2_ d_inverter
U16  Net-_U10-Pad3_ Net-_U16-Pad2_ d_inverter
U19  Net-_U14-Pad2_ Net-_U13-Pad2_ Net-_U19-Pad3_ d_or
U20  Net-_U14-Pad2_ Net-_U12-Pad2_ Net-_U20-Pad3_ d_or
U21  Net-_U14-Pad2_ Net-_U17-Pad2_ Net-_U21-Pad3_ d_or
U22  Net-_U18-Pad2_ Net-_U14-Pad2_ Net-_U22-Pad3_ d_or
U23  Net-_U12-Pad2_ Net-_U15-Pad2_ Net-_U23-Pad3_ d_or
U24  Net-_U13-Pad2_ Net-_U15-Pad2_ Net-_U24-Pad3_ d_or
U27  Net-_U13-Pad2_ Net-_U16-Pad2_ Net-_U27-Pad3_ d_or
U28  Net-_U12-Pad2_ Net-_U16-Pad2_ Net-_U28-Pad3_ d_or
U25  Net-_U17-Pad2_ Net-_U15-Pad2_ Net-_U25-Pad3_ d_or
U26  Net-_U18-Pad2_ Net-_U15-Pad2_ Net-_U26-Pad3_ d_or
U39  Net-_U19-Pad3_ Net-_U20-Pad3_ Net-_U21-Pad3_ Net-_U22-Pad3_ Net-_U23-Pad3_ Net-_U24-Pad3_ Net-_U25-Pad3_ ? Net-_U26-Pad3_ Net-_U27-Pad3_ Net-_U28-Pad3_ Net-_U10-Pad2_ Net-_U11-Pad1_ Net-_U1-Pad1_ Net-_U39-Pad15_ ? PORT

.end
