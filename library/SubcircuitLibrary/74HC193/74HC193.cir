* C:\FOSSEE\eSim\library\SubcircuitLibrary\74HC193\74HC193.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 5/21/2025 2:42:48 PM

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
X1  Net-_U1-Pad5_ Net-_U1-Pad3_ Net-_U1-Pad3_ Net-_U1-Pad7_ Net-_U1-Pad2_ Net-_U1-Pad4_ Net-_U1-Pad6_ Net-_U1-Pad8_ Net-_U4-Pad1_ jk_mux
X7  Net-_U1-Pad13_ Net-_U11-Pad3_ Net-_U11-Pad3_ Net-_U1-Pad7_ Net-_U1-Pad2_ Net-_U1-Pad4_ Net-_U1-Pad6_ Net-_U1-Pad14_ Net-_U13-Pad1_ jk_mux
X3  Net-_U1-Pad9_ Net-_U5-Pad3_ Net-_U5-Pad3_ Net-_U1-Pad7_ Net-_U1-Pad2_ Net-_U1-Pad4_ Net-_U1-Pad6_ Net-_U1-Pad10_ Net-_U7-Pad2_ jk_mux
X5  Net-_U1-Pad11_ Net-_U8-Pad3_ Net-_U8-Pad3_ Net-_U1-Pad7_ Net-_U1-Pad2_ Net-_U1-Pad4_ Net-_U1-Pad6_ Net-_U1-Pad12_ Net-_U10-Pad1_ jk_mux
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ Net-_U1-Pad16_ PORT
U2  Net-_U1-Pad1_ Net-_U2-Pad2_ d_inverter
U3  Net-_U1-Pad1_ Net-_U1-Pad8_ Net-_U3-Pad3_ d_and
U4  Net-_U4-Pad1_ Net-_U2-Pad2_ Net-_U4-Pad3_ d_and
U5  Net-_U3-Pad3_ Net-_U4-Pad3_ Net-_U5-Pad3_ d_or
U6  Net-_U3-Pad3_ Net-_U1-Pad10_ Net-_U6-Pad3_ d_and
U7  Net-_U4-Pad3_ Net-_U7-Pad2_ Net-_U10-Pad2_ d_and
U8  Net-_U6-Pad3_ Net-_U10-Pad2_ Net-_U8-Pad3_ d_or
U9  Net-_U6-Pad3_ Net-_U1-Pad12_ Net-_U11-Pad1_ d_and
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ Net-_U10-Pad3_ d_and
U11  Net-_U11-Pad1_ Net-_U10-Pad3_ Net-_U11-Pad3_ d_or
U13  Net-_U13-Pad1_ Net-_U10-Pad3_ Net-_U1-Pad16_ d_nand
U12  Net-_U11-Pad1_ Net-_U1-Pad14_ Net-_U12-Pad3_ d_and
U14  Net-_U12-Pad3_ Net-_U1-Pad15_ d_inverter

.end
