* C:\FOSSEE\eSim\library\SubcircuitLibrary\SN74S64\SN74S64.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 05/26/25 14:52:59

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U1  Net-_M2-Pad2_ Net-_M3-Pad2_ Net-_M12-Pad2_ Net-_M1-Pad2_ Net-_M10-Pad2_ Net-_M17-Pad2_ Net-_M1-Pad3_ Net-_M31-Pad1_ Net-_M5-Pad2_ Net-_M13-Pad2_ Net-_M11-Pad2_ Net-_M19-Pad2_ Net-_M27-Pad2_ Net-_M10-Pad3_ PORT
M2  Net-_M11-Pad3_ Net-_M2-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M11  Net-_M11-Pad1_ Net-_M11-Pad2_ Net-_M11-Pad3_ Net-_M1-Pad3_ mosfet_n
M19  Net-_M19-Pad1_ Net-_M19-Pad2_ Net-_M11-Pad1_ Net-_M1-Pad3_ mosfet_n
M27  Net-_M14-Pad1_ Net-_M27-Pad2_ Net-_M19-Pad1_ Net-_M1-Pad3_ mosfet_n
M29  Net-_M29-Pad1_ Net-_M14-Pad1_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M6  Net-_M14-Pad1_ Net-_M2-Pad2_ Net-_M10-Pad3_ Net-_M10-Pad3_ mosfet_p
M14  Net-_M14-Pad1_ Net-_M11-Pad2_ Net-_M10-Pad3_ Net-_M10-Pad3_ mosfet_p
M22  Net-_M14-Pad1_ Net-_M19-Pad2_ Net-_M10-Pad3_ Net-_M10-Pad3_ mosfet_p
M28  Net-_M14-Pad1_ Net-_M27-Pad2_ Net-_M10-Pad3_ Net-_M10-Pad3_ mosfet_p
M30  Net-_M29-Pad1_ Net-_M14-Pad1_ Net-_M10-Pad3_ Net-_M10-Pad3_ mosfet_p
M5  Net-_M13-Pad3_ Net-_M5-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M13  Net-_M13-Pad1_ Net-_M13-Pad2_ Net-_M13-Pad3_ Net-_M1-Pad3_ mosfet_n
M21  Net-_M21-Pad1_ Net-_M13-Pad1_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M1  Net-_M1-Pad1_ Net-_M1-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M9  Net-_M17-Pad3_ Net-_M10-Pad2_ Net-_M1-Pad1_ Net-_M1-Pad3_ mosfet_n
M8  Net-_M13-Pad1_ Net-_M5-Pad2_ Net-_M10-Pad3_ Net-_M10-Pad3_ mosfet_p
M16  Net-_M13-Pad1_ Net-_M13-Pad2_ Net-_M10-Pad3_ Net-_M10-Pad3_ mosfet_p
M24  Net-_M21-Pad1_ Net-_M13-Pad1_ Net-_M10-Pad3_ Net-_M10-Pad3_ mosfet_p
M4  Net-_M10-Pad1_ Net-_M1-Pad2_ Net-_M10-Pad3_ Net-_M10-Pad3_ mosfet_p
M10  Net-_M10-Pad1_ Net-_M10-Pad2_ Net-_M10-Pad3_ Net-_M10-Pad3_ mosfet_p
M3  Net-_M12-Pad3_ Net-_M3-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M12  Net-_M12-Pad1_ Net-_M12-Pad2_ Net-_M12-Pad3_ Net-_M1-Pad3_ mosfet_n
M20  Net-_M20-Pad1_ Net-_M12-Pad1_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M7  Net-_M12-Pad1_ Net-_M3-Pad2_ Net-_M10-Pad3_ Net-_M10-Pad3_ mosfet_p
M15  Net-_M12-Pad1_ Net-_M12-Pad2_ Net-_M10-Pad3_ Net-_M10-Pad3_ mosfet_p
M23  Net-_M20-Pad1_ Net-_M12-Pad1_ Net-_M10-Pad3_ Net-_M10-Pad3_ mosfet_p
M17  Net-_M10-Pad1_ Net-_M17-Pad2_ Net-_M17-Pad3_ Net-_M1-Pad3_ mosfet_n
M25  Net-_M25-Pad1_ Net-_M10-Pad1_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M18  Net-_M10-Pad1_ Net-_M17-Pad2_ Net-_M10-Pad3_ Net-_M10-Pad3_ mosfet_p
M26  Net-_M25-Pad1_ Net-_M10-Pad1_ Net-_M10-Pad3_ Net-_M10-Pad3_ mosfet_p
M31  Net-_M31-Pad1_ Net-_M21-Pad1_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M33  Net-_M31-Pad1_ Net-_M25-Pad1_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M32  Net-_M32-Pad1_ Net-_M21-Pad1_ Net-_M10-Pad3_ Net-_M10-Pad3_ mosfet_p
M34  Net-_M34-Pad1_ Net-_M25-Pad1_ Net-_M32-Pad1_ Net-_M10-Pad3_ mosfet_p
M35  Net-_M31-Pad1_ Net-_M20-Pad1_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M37  Net-_M31-Pad1_ Net-_M29-Pad1_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M36  Net-_M36-Pad1_ Net-_M20-Pad1_ Net-_M34-Pad1_ Net-_M10-Pad3_ mosfet_p
M38  Net-_M31-Pad1_ Net-_M29-Pad1_ Net-_M36-Pad1_ Net-_M10-Pad3_ mosfet_p

.end
