* D:\FOSSEE\eSim\library\SubcircuitLibrary\MC3403_IC\MC3403_IC.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 07/13/24 18:49:42

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
Q19  Net-_Q19-Pad1_ Net-_Q1-Pad2_ Net-_J1-Pad1_ eSim_PNP
Q22  Net-_Q22-Pad1_ Net-_Q1-Pad2_ Net-_J1-Pad1_ eSim_PNP
Q42  Net-_Q1-Pad2_ Net-_Q1-Pad2_ Net-_J1-Pad1_ eSim_PNP
Q43  Net-_C1-Pad1_ Net-_Q1-Pad2_ Net-_J1-Pad1_ eSim_PNP
Q47  Net-_J1-Pad1_ Net-_C1-Pad1_ Net-_Q47-Pad3_ eSim_NPN
Q49  Net-_J1-Pad1_ Net-_Q47-Pad3_ Net-_Q49-Pad3_ eSim_NPN
Q10  Net-_Q10-Pad1_ Net-_Q1-Pad2_ Net-_J1-Pad1_ eSim_PNP
Q4  Net-_Q12-Pad3_ Net-_Q1-Pad2_ Net-_J1-Pad1_ eSim_PNP
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_J1-Pad1_ eSim_PNP
Q2  Net-_J1-Pad2_ Net-_Q12-Pad1_ Net-_Q1-Pad1_ eSim_PNP
Q7  Net-_Q12-Pad2_ Net-_Q12-Pad2_ Net-_Q12-Pad3_ eSim_PNP
Q12  Net-_Q12-Pad1_ Net-_Q12-Pad2_ Net-_Q12-Pad3_ eSim_PNP
Q18  Net-_C1-Pad2_ Net-_Q18-Pad2_ Net-_Q12-Pad3_ eSim_PNP
Q21  Net-_Q18-Pad2_ Net-_Q18-Pad2_ Net-_Q12-Pad3_ eSim_PNP
Q3  Net-_J1-Pad2_ Net-_Q3-Pad2_ Net-_Q12-Pad2_ eSim_PNP
Q8  Net-_Q12-Pad1_ Net-_Q12-Pad1_ Net-_J1-Pad2_ eSim_NPN
Q16  Net-_C1-Pad2_ Net-_Q12-Pad1_ Net-_J1-Pad2_ eSim_NPN
Q25  Net-_J1-Pad2_ Net-_Q25-Pad2_ Net-_Q18-Pad2_ eSim_PNP
Q29  Net-_J1-Pad2_ Net-_C1-Pad2_ Net-_Q10-Pad1_ eSim_PNP
Q30  Net-_Q19-Pad1_ Net-_Q10-Pad1_ Net-_Q30-Pad3_ eSim_NPN
Q32  Net-_Q30-Pad3_ Net-_Q22-Pad1_ Net-_Q32-Pad3_ eSim_NPN
R3  Net-_Q32-Pad3_ Net-_J1-Pad2_ 12k
Q35  Net-_J1-Pad2_ Net-_Q22-Pad1_ Net-_Q19-Pad1_ eSim_PNP
Q37  Net-_Q22-Pad1_ Net-_Q22-Pad1_ Net-_J1-Pad2_ eSim_NPN
Q39  Net-_Q1-Pad2_ Net-_Q39-Pad2_ Net-_Q39-Pad3_ eSim_NPN
R5  Net-_Q39-Pad3_ Net-_J1-Pad2_ 0.7k
Q41  Net-_C1-Pad1_ Net-_Q30-Pad3_ Net-_J1-Pad2_ eSim_NPN
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 8p
Q50  Net-_Q49-Pad3_ Net-_Q50-Pad2_ Net-_Q50-Pad3_ eSim_NPN
Q51  Net-_Q50-Pad3_ Net-_Q22-Pad1_ Net-_J1-Pad2_ eSim_NPN
R9  Net-_Q49-Pad3_ Net-_Q50-Pad2_ 31k
R10  Net-_Q50-Pad2_ Net-_Q50-Pad3_ 37k
Q57  Net-_J1-Pad1_ Net-_Q47-Pad3_ Net-_Q57-Pad3_ eSim_NPN
R13  Net-_Q57-Pad3_ Net-_Q58-Pad3_ 25
Q58  Net-_J1-Pad2_ Net-_Q55-Pad3_ Net-_Q58-Pad3_ eSim_PNP
Q55  Net-_J1-Pad2_ Net-_Q50-Pad3_ Net-_Q55-Pad3_ eSim_PNP
Q61  Net-_C1-Pad1_ Net-_Q57-Pad3_ Net-_Q58-Pad3_ eSim_NPN
Q63  Net-_J1-Pad3_ Net-_J1-Pad3_ Net-_Q39-Pad2_ eSim_NPN
Q67  Net-_J1-Pad1_ Net-_J1-Pad3_ Net-_Q64-Pad2_ eSim_NPN
J1  Net-_J1-Pad1_ Net-_J1-Pad2_ Net-_J1-Pad3_ jfet_n
Q64  Net-_Q39-Pad2_ Net-_Q64-Pad2_ Net-_J1-Pad2_ eSim_NPN
R15  Net-_Q64-Pad2_ Net-_J1-Pad2_ 8.2k
Q89  Net-_Q103-Pad3_ Net-_Q107-Pad1_ Net-_J1-Pad1_ eSim_PNP
Q93  Net-_Q101-Pad2_ Net-_Q107-Pad1_ Net-_J1-Pad1_ eSim_PNP
Q111  Net-_Q107-Pad1_ Net-_Q107-Pad1_ Net-_J1-Pad1_ eSim_PNP
Q113  Net-_C3-Pad1_ Net-_Q107-Pad1_ Net-_J1-Pad1_ eSim_PNP
Q115  Net-_J1-Pad1_ Net-_C3-Pad1_ Net-_Q115-Pad3_ eSim_NPN
Q117  Net-_J1-Pad1_ Net-_Q115-Pad3_ Net-_Q117-Pad3_ eSim_NPN
Q81  Net-_Q81-Pad1_ Net-_Q107-Pad1_ Net-_J1-Pad1_ eSim_PNP
Q75  Net-_Q75-Pad1_ Net-_Q107-Pad1_ Net-_J1-Pad1_ eSim_PNP
Q69  Net-_Q69-Pad1_ Net-_Q107-Pad1_ Net-_J1-Pad1_ eSim_PNP
Q71  Net-_J1-Pad2_ Net-_Q71-Pad2_ Net-_Q69-Pad1_ eSim_PNP
Q77  Net-_Q73-Pad3_ Net-_Q73-Pad3_ Net-_Q75-Pad1_ eSim_PNP
Q83  Net-_Q71-Pad2_ Net-_Q73-Pad3_ Net-_Q75-Pad1_ eSim_PNP
Q87  Net-_C3-Pad2_ Net-_Q87-Pad2_ Net-_Q75-Pad1_ eSim_PNP
Q91  Net-_Q87-Pad2_ Net-_Q87-Pad2_ Net-_Q75-Pad1_ eSim_PNP
Q73  Net-_J1-Pad2_ Net-_Q73-Pad2_ Net-_Q73-Pad3_ eSim_PNP
Q79  Net-_Q71-Pad2_ Net-_Q71-Pad2_ Net-_J1-Pad2_ eSim_NPN
Q85  Net-_C3-Pad2_ Net-_Q71-Pad2_ Net-_J1-Pad2_ eSim_NPN
Q95  Net-_J1-Pad2_ Net-_Q95-Pad2_ Net-_Q87-Pad2_ eSim_PNP
Q97  Net-_J1-Pad2_ Net-_C3-Pad2_ Net-_Q81-Pad1_ eSim_PNP
Q99  Net-_Q103-Pad3_ Net-_Q81-Pad1_ Net-_Q101-Pad1_ eSim_NPN
Q101  Net-_Q101-Pad1_ Net-_Q101-Pad2_ Net-_Q101-Pad3_ eSim_NPN
R19  Net-_Q101-Pad3_ Net-_J1-Pad2_ 12k
Q103  Net-_J1-Pad2_ Net-_Q101-Pad2_ Net-_Q103-Pad3_ eSim_PNP
Q105  Net-_Q101-Pad2_ Net-_Q101-Pad2_ Net-_J1-Pad2_ eSim_NPN
Q107  Net-_Q107-Pad1_ Net-_Q107-Pad2_ Net-_Q107-Pad3_ eSim_NPN
R21  Net-_Q107-Pad3_ Net-_J1-Pad2_ 0.7k
Q109  Net-_C3-Pad1_ Net-_Q101-Pad1_ Net-_J1-Pad2_ eSim_NPN
C3  Net-_C3-Pad1_ Net-_C3-Pad2_ 8p
Q118  Net-_Q117-Pad3_ Net-_Q118-Pad2_ Net-_Q118-Pad3_ eSim_NPN
Q119  Net-_Q118-Pad3_ Net-_Q101-Pad2_ Net-_J1-Pad2_ eSim_NPN
R25  Net-_Q117-Pad3_ Net-_Q118-Pad2_ 31k
R26  Net-_Q118-Pad2_ Net-_Q118-Pad3_ 37k
Q125  Net-_J1-Pad1_ Net-_Q115-Pad3_ Net-_Q125-Pad3_ eSim_NPN
R29  Net-_Q125-Pad3_ Net-_Q126-Pad3_ 25
Q126  Net-_J1-Pad2_ Net-_Q123-Pad3_ Net-_Q126-Pad3_ eSim_PNP
Q123  Net-_J1-Pad2_ Net-_Q118-Pad3_ Net-_Q123-Pad3_ eSim_PNP
Q129  Net-_C3-Pad1_ Net-_Q125-Pad3_ Net-_Q126-Pad3_ eSim_NPN
Q131  Net-_J3-Pad3_ Net-_J3-Pad3_ Net-_Q107-Pad2_ eSim_NPN
Q135  Net-_J1-Pad1_ Net-_J3-Pad3_ Net-_Q132-Pad2_ eSim_NPN
J3  Net-_J1-Pad1_ Net-_J1-Pad2_ Net-_J3-Pad3_ jfet_n
Q132  Net-_Q107-Pad2_ Net-_Q132-Pad2_ Net-_J1-Pad2_ eSim_NPN
R31  Net-_Q132-Pad2_ Net-_J1-Pad2_ 8.2k
Q24  Net-_Q24-Pad1_ Net-_Q11-Pad2_ Net-_J1-Pad1_ eSim_PNP
Q27  Net-_Q27-Pad1_ Net-_Q11-Pad2_ Net-_J1-Pad1_ eSim_PNP
Q45  Net-_Q11-Pad2_ Net-_Q11-Pad2_ Net-_J1-Pad1_ eSim_PNP
Q46  Net-_C2-Pad1_ Net-_Q11-Pad2_ Net-_J1-Pad1_ eSim_PNP
Q48  Net-_J1-Pad1_ Net-_C2-Pad1_ Net-_Q48-Pad3_ eSim_NPN
Q52  Net-_J1-Pad1_ Net-_Q48-Pad3_ Net-_Q52-Pad3_ eSim_NPN
Q15  Net-_Q15-Pad1_ Net-_Q11-Pad2_ Net-_J1-Pad1_ eSim_PNP
Q11  Net-_Q11-Pad1_ Net-_Q11-Pad2_ Net-_J1-Pad1_ eSim_PNP
Q5  Net-_Q5-Pad1_ Net-_Q11-Pad2_ Net-_J1-Pad1_ eSim_PNP
Q6  Net-_J1-Pad2_ Net-_Q14-Pad1_ Net-_Q5-Pad1_ eSim_PNP
Q13  Net-_Q13-Pad1_ Net-_Q13-Pad1_ Net-_Q11-Pad1_ eSim_PNP
Q17  Net-_Q14-Pad1_ Net-_Q13-Pad1_ Net-_Q11-Pad1_ eSim_PNP
Q23  Net-_C2-Pad2_ Net-_Q23-Pad2_ Net-_Q11-Pad1_ eSim_PNP
Q26  Net-_Q23-Pad2_ Net-_Q23-Pad2_ Net-_Q11-Pad1_ eSim_PNP
Q9  Net-_J1-Pad2_ Net-_Q9-Pad2_ Net-_Q13-Pad1_ eSim_PNP
Q14  Net-_Q14-Pad1_ Net-_Q14-Pad1_ Net-_J1-Pad2_ eSim_NPN
Q20  Net-_C2-Pad2_ Net-_Q14-Pad1_ Net-_J1-Pad2_ eSim_NPN
Q28  Net-_J1-Pad2_ Net-_Q28-Pad2_ Net-_Q23-Pad2_ eSim_PNP
Q31  Net-_J1-Pad2_ Net-_C2-Pad2_ Net-_Q15-Pad1_ eSim_PNP
Q33  Net-_Q24-Pad1_ Net-_Q15-Pad1_ Net-_Q33-Pad3_ eSim_NPN
Q34  Net-_Q33-Pad3_ Net-_Q27-Pad1_ Net-_Q34-Pad3_ eSim_NPN
R4  Net-_Q34-Pad3_ Net-_J1-Pad2_ 12k
Q36  Net-_J1-Pad2_ Net-_Q27-Pad1_ Net-_Q24-Pad1_ eSim_PNP
Q38  Net-_Q27-Pad1_ Net-_Q27-Pad1_ Net-_J1-Pad2_ eSim_NPN
Q40  Net-_Q11-Pad2_ Net-_Q40-Pad2_ Net-_Q40-Pad3_ eSim_NPN
R6  Net-_Q40-Pad3_ Net-_J1-Pad2_ 0.7k
Q44  Net-_C2-Pad1_ Net-_Q33-Pad3_ Net-_J1-Pad2_ eSim_NPN
C2  Net-_C2-Pad1_ Net-_C2-Pad2_ 8p
Q53  Net-_Q52-Pad3_ Net-_Q53-Pad2_ Net-_Q53-Pad3_ eSim_NPN
Q54  Net-_Q53-Pad3_ Net-_Q27-Pad1_ Net-_J1-Pad2_ eSim_NPN
R11  Net-_Q52-Pad3_ Net-_Q53-Pad2_ 31k
R12  Net-_Q53-Pad2_ Net-_Q53-Pad3_ 37k
Q59  Net-_J1-Pad1_ Net-_Q48-Pad3_ Net-_Q59-Pad3_ eSim_NPN
R14  Net-_Q59-Pad3_ Net-_Q60-Pad3_ 25
Q60  Net-_J1-Pad2_ Net-_Q56-Pad3_ Net-_Q60-Pad3_ eSim_PNP
Q56  Net-_J1-Pad2_ Net-_Q53-Pad3_ Net-_Q56-Pad3_ eSim_PNP
Q62  Net-_C2-Pad1_ Net-_Q59-Pad3_ Net-_Q60-Pad3_ eSim_NPN
Q65  Net-_J2-Pad3_ Net-_J2-Pad3_ Net-_Q40-Pad2_ eSim_NPN
Q68  Net-_J1-Pad1_ Net-_J2-Pad3_ Net-_Q66-Pad2_ eSim_NPN
J2  Net-_J1-Pad1_ Net-_J1-Pad2_ Net-_J2-Pad3_ jfet_n
Q66  Net-_Q40-Pad2_ Net-_Q66-Pad2_ Net-_J1-Pad2_ eSim_NPN
R16  Net-_Q66-Pad2_ Net-_J1-Pad2_ 8.2k
Q90  Net-_Q100-Pad1_ Net-_Q108-Pad1_ Net-_J1-Pad1_ eSim_PNP
Q94  Net-_Q102-Pad2_ Net-_Q108-Pad1_ Net-_J1-Pad1_ eSim_PNP
Q112  Net-_Q108-Pad1_ Net-_Q108-Pad1_ Net-_J1-Pad1_ eSim_PNP
Q114  Net-_C4-Pad1_ Net-_Q108-Pad1_ Net-_J1-Pad1_ eSim_PNP
Q116  Net-_J1-Pad1_ Net-_C4-Pad1_ Net-_Q116-Pad3_ eSim_NPN
Q120  Net-_J1-Pad1_ Net-_Q116-Pad3_ Net-_Q120-Pad3_ eSim_NPN
Q82  Net-_Q100-Pad2_ Net-_Q108-Pad1_ Net-_J1-Pad1_ eSim_PNP
Q76  Net-_Q76-Pad1_ Net-_Q108-Pad1_ Net-_J1-Pad1_ eSim_PNP
Q70  Net-_Q70-Pad1_ Net-_Q108-Pad1_ Net-_J1-Pad1_ eSim_PNP
Q72  Net-_J1-Pad2_ Net-_Q72-Pad2_ Net-_Q70-Pad1_ eSim_PNP
Q78  Net-_Q74-Pad3_ Net-_Q74-Pad3_ Net-_Q76-Pad1_ eSim_PNP
Q84  Net-_Q72-Pad2_ Net-_Q74-Pad3_ Net-_Q76-Pad1_ eSim_PNP
Q88  Net-_C4-Pad2_ Net-_Q88-Pad2_ Net-_Q76-Pad1_ eSim_PNP
Q92  Net-_Q88-Pad2_ Net-_Q88-Pad2_ Net-_Q76-Pad1_ eSim_PNP
Q74  Net-_J1-Pad2_ Net-_Q74-Pad2_ Net-_Q74-Pad3_ eSim_PNP
Q80  Net-_Q72-Pad2_ Net-_Q72-Pad2_ Net-_J1-Pad2_ eSim_NPN
Q86  Net-_C4-Pad2_ Net-_Q72-Pad2_ Net-_J1-Pad2_ eSim_NPN
Q96  Net-_J1-Pad2_ Net-_Q96-Pad2_ Net-_Q88-Pad2_ eSim_PNP
Q98  Net-_J1-Pad2_ Net-_C4-Pad2_ Net-_Q100-Pad2_ eSim_PNP
Q100  Net-_Q100-Pad1_ Net-_Q100-Pad2_ Net-_Q100-Pad3_ eSim_NPN
Q102  Net-_Q100-Pad3_ Net-_Q102-Pad2_ Net-_Q102-Pad3_ eSim_NPN
R20  Net-_Q102-Pad3_ Net-_J1-Pad2_ 12k
Q104  Net-_J1-Pad2_ Net-_Q102-Pad2_ Net-_Q100-Pad1_ eSim_PNP
Q106  Net-_Q102-Pad2_ Net-_Q102-Pad2_ Net-_J1-Pad2_ eSim_NPN
Q108  Net-_Q108-Pad1_ Net-_Q108-Pad2_ Net-_Q108-Pad3_ eSim_NPN
R22  Net-_Q108-Pad3_ Net-_J1-Pad2_ 0.7k
Q110  Net-_C4-Pad1_ Net-_Q100-Pad3_ Net-_J1-Pad2_ eSim_NPN
C4  Net-_C4-Pad1_ Net-_C4-Pad2_ 8p
Q121  Net-_Q120-Pad3_ Net-_Q121-Pad2_ Net-_Q121-Pad3_ eSim_NPN
Q122  Net-_Q121-Pad3_ Net-_Q102-Pad2_ Net-_J1-Pad2_ eSim_NPN
R27  Net-_Q120-Pad3_ Net-_Q121-Pad2_ 31k
R28  Net-_Q121-Pad2_ Net-_Q121-Pad3_ 37k
Q127  Net-_J1-Pad1_ Net-_Q116-Pad3_ Net-_Q127-Pad3_ eSim_NPN
R30  Net-_Q127-Pad3_ Net-_Q128-Pad3_ 25
Q128  Net-_J1-Pad2_ Net-_Q124-Pad3_ Net-_Q128-Pad3_ eSim_PNP
Q124  Net-_J1-Pad2_ Net-_Q121-Pad3_ Net-_Q124-Pad3_ eSim_PNP
Q130  Net-_C4-Pad1_ Net-_Q127-Pad3_ Net-_Q128-Pad3_ eSim_NPN
Q133  Net-_J4-Pad3_ Net-_J4-Pad3_ Net-_Q108-Pad2_ eSim_NPN
Q136  Net-_J1-Pad1_ Net-_J4-Pad3_ Net-_Q134-Pad2_ eSim_NPN
J4  Net-_J1-Pad1_ Net-_J1-Pad2_ Net-_J4-Pad3_ jfet_n
Q134  Net-_Q108-Pad2_ Net-_Q134-Pad2_ Net-_J1-Pad2_ eSim_NPN
R32  Net-_Q134-Pad2_ Net-_J1-Pad2_ 8.2k
U1  Net-_Q58-Pad3_ Net-_Q3-Pad2_ Net-_Q25-Pad2_ Net-_J1-Pad1_ Net-_Q28-Pad2_ Net-_Q9-Pad2_ Net-_Q60-Pad3_ Net-_Q126-Pad3_ Net-_Q73-Pad2_ Net-_Q95-Pad2_ Net-_J1-Pad2_ Net-_Q96-Pad2_ Net-_Q74-Pad2_ Net-_Q128-Pad3_ PORT

.end
