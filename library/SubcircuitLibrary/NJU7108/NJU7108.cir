* C:\Users\HP\OneDrive\Documents\FOSSEE\eSim\library\SubcircuitLibrary\NJU7108\NJU7108.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/19/25 15:30:28

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
M1  Net-_M1-Pad1_ Net-_C1-Pad1_ Net-_C1-Pad1_ Net-_M1-Pad1_ mosfet_p
M4  Net-_M4-Pad1_ Net-_C1-Pad1_ Net-_M2-Pad2_ Net-_M4-Pad1_ mosfet_p
M2  Net-_C1-Pad1_ Net-_M2-Pad2_ Net-_C1-Pad2_ Net-_C1-Pad2_ mosfet_n
M3  Net-_M2-Pad2_ Net-_M2-Pad2_ Net-_C1-Pad2_ Net-_C1-Pad2_ mosfet_n
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 1p
M6  Net-_M1-Pad1_ Net-_M11-Pad2_ Net-_M11-Pad2_ Net-_M1-Pad1_ mosfet_p
M5  Net-_M11-Pad2_ Net-_M2-Pad2_ Net-_C1-Pad2_ Net-_C1-Pad2_ mosfet_n
M7  Net-_M1-Pad1_ Net-_M15-Pad2_ Net-_M15-Pad2_ Net-_M1-Pad1_ mosfet_p
M8  Net-_M15-Pad2_ Net-_M10-Pad1_ Net-_C1-Pad2_ Net-_C1-Pad2_ mosfet_n
M9  Net-_M11-Pad3_ Net-_M9-Pad2_ Net-_M10-Pad1_ Net-_M1-Pad1_ mosfet_p
M13  Net-_M11-Pad3_ Net-_M13-Pad2_ Net-_M12-Pad1_ Net-_M1-Pad1_ mosfet_p
M11  Net-_M1-Pad1_ Net-_M11-Pad2_ Net-_M11-Pad3_ Net-_M1-Pad1_ mosfet_p
M10  Net-_M10-Pad1_ Net-_M10-Pad1_ Net-_M10-Pad3_ Net-_C1-Pad2_ mosfet_n
M12  Net-_M12-Pad1_ Net-_M10-Pad1_ Net-_M12-Pad3_ Net-_C1-Pad2_ mosfet_n
M15  Net-_M1-Pad1_ Net-_M15-Pad2_ Net-_M14-Pad1_ Net-_M1-Pad1_ mosfet_p
M14  Net-_M14-Pad1_ Net-_M12-Pad1_ Net-_C1-Pad2_ Net-_C1-Pad2_ mosfet_n
M17  Net-_M1-Pad1_ Net-_M14-Pad1_ Net-_M16-Pad1_ Net-_M1-Pad1_ mosfet_p
M16  Net-_M16-Pad1_ Net-_M14-Pad1_ Net-_C1-Pad2_ Net-_C1-Pad2_ mosfet_n
M19  Net-_M1-Pad1_ Net-_M16-Pad1_ Net-_M18-Pad1_ Net-_M1-Pad1_ mosfet_p
M18  Net-_M18-Pad1_ Net-_M16-Pad1_ Net-_C1-Pad2_ Net-_C1-Pad2_ mosfet_n
R1  Net-_M1-Pad1_ Net-_M4-Pad1_ 1k
R2  Net-_M10-Pad3_ Net-_C1-Pad2_ 3k
R3  Net-_M12-Pad3_ Net-_C1-Pad2_ 3k
U1  Net-_M1-Pad1_ Net-_M13-Pad2_ Net-_M9-Pad2_ Net-_C1-Pad2_ Net-_M18-Pad1_ PORT

.end
