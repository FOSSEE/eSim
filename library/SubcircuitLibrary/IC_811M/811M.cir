* E:\FOSSEE\eSim\library\SubcircuitLibrary\811M\811M.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/08/25 22:03:52

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
Q4  Net-_Q4-Pad1_ Net-_Q4-Pad2_ Net-_Q1-Pad3_ eSim_NPN
Q3  Net-_Q1-Pad3_ Net-_Q11-Pad1_ Net-_Q3-Pad3_ eSim_NPN
R2  Net-_Q3-Pad3_ Net-_R16-Pad2_ 0.24k
R1  Net-_Q2-Pad3_ Net-_Q1-Pad1_ 0.91k
R3  Net-_Q2-Pad3_ Net-_Q7-Pad2_ 0.91k
R4  Net-_Q7-Pad2_ Net-_Q4-Pad1_ 0.1k
Q2  Net-_D1-Pad1_ Net-_Q2-Pad2_ Net-_Q2-Pad3_ eSim_NPN
R5  Net-_D1-Pad1_ Net-_Q2-Pad2_ 4.3k
Q5  Net-_Q2-Pad2_ Net-_Q1-Pad1_ Net-_Q5-Pad3_ eSim_NPN
Q6  Net-_Q2-Pad2_ Net-_Q4-Pad1_ Net-_Q5-Pad3_ eSim_NPN
Q7  Net-_Q7-Pad1_ Net-_Q7-Pad2_ Net-_Q5-Pad3_ eSim_NPN
R6  Net-_D2-Pad2_ Net-_Q7-Pad1_ 5.3k
D2  Net-_D1-Pad2_ Net-_D2-Pad2_ eSim_Diode
D1  Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
U2  Net-_Q10-Pad2_ Net-_Q5-Pad3_ zener
Q8  Net-_Q8-Pad1_ Net-_Q7-Pad1_ Net-_Q5-Pad3_ eSim_NPN
R7  Net-_D1-Pad2_ Net-_Q8-Pad1_ 4.3k
U3  Net-_U1-Pad5_ Net-_Q8-Pad1_ zener
Q9  Net-_D1-Pad1_ Net-_Q8-Pad1_ Net-_Q9-Pad3_ eSim_NPN
U4  Net-_Q10-Pad1_ Net-_Q9-Pad3_ zener
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
R8  Net-_Q10-Pad3_ Net-_Q11-Pad1_ 5.05k
Q11  Net-_Q11-Pad1_ Net-_Q11-Pad1_ Net-_Q11-Pad3_ eSim_NPN
R9  Net-_Q11-Pad3_ Net-_R16-Pad2_ 0.24k
Q12  Net-_D1-Pad1_ Net-_Q12-Pad2_ Net-_Q12-Pad3_ eSim_NPN
U5  Net-_Q10-Pad1_ Net-_Q12-Pad3_ zener
U6  Net-_U1-Pad8_ Net-_Q12-Pad2_ zener
R10  Net-_D3-Pad2_ Net-_Q12-Pad2_ 4.3k
Q13  Net-_Q12-Pad2_ Net-_Q13-Pad2_ Net-_Q13-Pad3_ eSim_NPN
D3  Net-_D1-Pad1_ Net-_D3-Pad2_ eSim_Diode
D4  Net-_D3-Pad2_ Net-_D4-Pad2_ eSim_Diode
R11  Net-_D4-Pad2_ Net-_Q13-Pad2_ 5.3k
Q14  Net-_Q13-Pad2_ Net-_Q14-Pad2_ Net-_Q13-Pad3_ eSim_NPN
U7  Net-_Q10-Pad2_ Net-_Q13-Pad3_ zener
Q15  Net-_Q15-Pad1_ Net-_Q15-Pad2_ Net-_Q13-Pad3_ eSim_NPN
R12  Net-_D1-Pad1_ Net-_Q15-Pad1_ 4.3k
Q16  Net-_Q15-Pad1_ Net-_Q16-Pad2_ Net-_Q13-Pad3_ eSim_NPN
Q18  Net-_D1-Pad1_ Net-_Q15-Pad1_ Net-_Q18-Pad3_ eSim_NPN
R15  Net-_Q18-Pad3_ Net-_Q16-Pad2_ 0.91k
R13  Net-_Q18-Pad3_ Net-_Q14-Pad2_ 0.91k
R14  Net-_Q14-Pad2_ Net-_Q15-Pad2_ 0.1k
Q17  Net-_Q15-Pad2_ Net-_Q17-Pad2_ Net-_Q17-Pad3_ eSim_NPN
Q20  Net-_Q16-Pad2_ Net-_Q20-Pad2_ Net-_Q17-Pad3_ eSim_NPN
Q19  Net-_Q17-Pad3_ Net-_Q11-Pad1_ Net-_Q19-Pad3_ eSim_NPN
R16  Net-_Q19-Pad3_ Net-_R16-Pad2_ 0.24k
U1  Net-_Q1-Pad2_ Net-_Q4-Pad2_ Net-_D1-Pad1_ Net-_Q10-Pad2_ Net-_U1-Pad5_ Net-_Q10-Pad1_ Net-_R16-Pad2_ Net-_U1-Pad8_ Net-_Q20-Pad2_ Net-_Q17-Pad2_ PORT

.end
