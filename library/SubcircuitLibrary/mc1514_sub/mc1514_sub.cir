.title KiCad schematic
R14 Net-_R14-Pad1_ Net-_D4-Pad2_ 100
D4 Net-_D4-Pad1_ Net-_D4-Pad2_ eSim_Diode
U1 Net-_Q8-Pad1_ Net-_U1-Pad2_ Net-_Q2-Pad1_ unconnected-_U1-Pad4_ Net-_Q13-Pad2_ Net-_Q16-Pad2_ Net-_R2-Pad1_ Net-_Q10-Pad1_ Net-_U1-Pad9_ Net-_Q15-Pad1_ Net-_Q10-Pad2_ Net-_Q4-Pad2_ Net-_Q1-Pad2_ Net-_R14-Pad1_ PORT
Q13 Net-_Q12-Pad2_ Net-_Q13-Pad2_ Net-_Q13-Pad3_ eSim_NPN
Q16 Net-_Q11-Pad2_ Net-_Q16-Pad2_ Net-_Q13-Pad3_ eSim_NPN
Q14 Net-_Q13-Pad3_ Net-_D4-Pad1_ Net-_Q14-Pad3_ eSim_NPN
R16 Net-_R14-Pad1_ Net-_Q14-Pad3_ 200
U7 Net-_Q10-Pad2_ Net-_Q11-Pad3_ zener
R12 Net-_Q10-Pad3_ Net-_D4-Pad1_ 1k
R6 Net-_Q8-Pad3_ Net-_D1-Pad1_ 1k
Q10 Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
Q8 Net-_Q8-Pad1_ Net-_Q10-Pad2_ Net-_Q8-Pad3_ eSim_NPN
U2 Net-_Q10-Pad2_ Net-_Q5-Pad3_ zener
R5 Net-_D2-Pad1_ Net-_Q2-Pad1_ 3.7k
R7 Net-_D2-Pad2_ Net-_Q2-Pad1_ 2.8k
D2 Net-_D2-Pad1_ Net-_D2-Pad2_ eSim_Diode
Q2 Net-_Q2-Pad1_ Net-_Q2-Pad2_ Net-_Q2-Pad3_ eSim_NPN
R1 Net-_Q1-Pad1_ Net-_Q2-Pad3_ 740
R3 Net-_Q4-Pad1_ Net-_Q2-Pad3_ 740
Q5 Net-_D2-Pad1_ Net-_Q4-Pad1_ Net-_Q5-Pad3_ eSim_NPN
Q6 Net-_Q2-Pad2_ Net-_Q1-Pad1_ Net-_Q5-Pad3_ eSim_NPN
R8 Net-_Q2-Pad2_ Net-_D2-Pad2_ 1.1k
R17 Net-_Q11-Pad2_ Net-_Q15-Pad3_ 740
R13 Net-_D3-Pad1_ Net-_Q15-Pad1_ 3.7k
Q15 Net-_Q15-Pad1_ Net-_Q11-Pad1_ Net-_Q15-Pad3_ eSim_NPN
R15 Net-_Q12-Pad2_ Net-_Q15-Pad3_ 740
R9 Net-_Q15-Pad1_ Net-_Q2-Pad1_ 47
U4 Net-_Q8-Pad1_ Net-_Q7-Pad3_ zener
U5 Net-_Q10-Pad1_ Net-_Q9-Pad3_ zener
Q9 Net-_Q15-Pad1_ Net-_D3-Pad1_ Net-_Q9-Pad3_ eSim_NPN
Q7 Net-_Q2-Pad1_ Net-_D2-Pad1_ Net-_Q7-Pad3_ eSim_NPN
U3 Net-_U1-Pad2_ Net-_D2-Pad1_ zener
U6 Net-_U1-Pad9_ Net-_D3-Pad1_ zener
D3 Net-_D3-Pad1_ Net-_D3-Pad2_ eSim_Diode
Q11 Net-_Q11-Pad1_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_NPN
Q12 Net-_D3-Pad1_ Net-_Q12-Pad2_ Net-_Q11-Pad3_ eSim_NPN
R10 Net-_D3-Pad2_ Net-_Q15-Pad1_ 2.8k
R11 Net-_Q11-Pad1_ Net-_D3-Pad2_ 1.1k
R4 Net-_R2-Pad1_ Net-_D1-Pad2_ 100
Q3 Net-_Q1-Pad3_ Net-_D1-Pad1_ Net-_Q3-Pad3_ eSim_NPN
D1 Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
R2 Net-_R2-Pad1_ Net-_Q3-Pad3_ 200
Q4 Net-_Q4-Pad1_ Net-_Q4-Pad2_ Net-_Q1-Pad3_ eSim_NPN
Q1 Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
.end
