* C:\FOSSEE\eSim\library\SubcircuitLibrary\L601\L601.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 02/03/25 18:35:59

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
Q2  Net-_D8-Pad2_ Net-_D2-Pad2_ Net-_Q2-Pad3_ eSim_NPN
Q5  Net-_D5-Pad1_ Net-_Q2-Pad3_ GND eSim_NPN
R2  Net-_D2-Pad2_ Net-_Q2-Pad3_ 7.2k
R5  Net-_Q2-Pad3_ GND 3k
D8  GND Net-_D8-Pad2_ eSim_Diode
D2  GND Net-_D2-Pad2_ eSim_Diode
D5  Net-_D5-Pad1_ COM eSim_Diode
Q3  Net-_D9-Pad2_ Net-_D3-Pad2_ Net-_Q3-Pad3_ eSim_NPN
Q6  Net-_D6-Pad1_ Net-_Q3-Pad3_ GND eSim_NPN
R3  Net-_D3-Pad2_ Net-_Q3-Pad3_ 7.2k
R6  Net-_Q3-Pad3_ GND 3k
D9  GND Net-_D9-Pad2_ eSim_Diode
D3  GND Net-_D3-Pad2_ eSim_Diode
D6  Net-_D6-Pad1_ COM eSim_Diode
Q1  Net-_D7-Pad2_ Net-_D1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
Q4  Net-_D4-Pad1_ Net-_Q1-Pad3_ GND eSim_NPN
R1  Net-_D1-Pad2_ Net-_Q1-Pad3_ 7.2k
R4  Net-_Q1-Pad3_ GND 3k
D7  GND Net-_D7-Pad2_ eSim_Diode
D1  GND Net-_D1-Pad2_ eSim_Diode
D4  Net-_D4-Pad1_ COM eSim_Diode
Q11  Net-_D21-Pad2_ Net-_D16-Pad2_ Net-_Q11-Pad3_ eSim_NPN
Q14  Net-_D19-Pad1_ Net-_Q11-Pad3_ GND eSim_NPN
R11  Net-_D16-Pad2_ Net-_Q11-Pad3_ 7.2k
R14  Net-_Q11-Pad3_ GND 3k
D21  GND Net-_D21-Pad2_ eSim_Diode
D16  GND Net-_D16-Pad2_ eSim_Diode
D19  Net-_D19-Pad1_ COM eSim_Diode
Q12  Net-_D23-Pad2_ Net-_D17-Pad2_ Net-_Q12-Pad3_ eSim_NPN
Q15  Net-_D20-Pad1_ Net-_Q12-Pad3_ GND eSim_NPN
R12  Net-_D17-Pad2_ Net-_Q12-Pad3_ 7.2k
R15  Net-_Q12-Pad3_ GND 3k
D23  GND Net-_D23-Pad2_ eSim_Diode
D17  GND Net-_D17-Pad2_ eSim_Diode
D20  Net-_D20-Pad1_ COM eSim_Diode
Q7  Net-_D14-Pad2_ Net-_D10-Pad2_ Net-_Q7-Pad3_ eSim_NPN
Q9  Net-_D12-Pad1_ Net-_Q7-Pad3_ GND eSim_NPN
R7  Net-_D10-Pad2_ Net-_Q7-Pad3_ 7.2k
R9  Net-_Q7-Pad3_ GND 3k
D14  GND Net-_D14-Pad2_ eSim_Diode
D10  GND Net-_D10-Pad2_ eSim_Diode
D12  Net-_D12-Pad1_ COM eSim_Diode
Q13  Net-_D24-Pad2_ Net-_D18-Pad2_ Net-_Q13-Pad3_ eSim_NPN
Q16  Net-_D22-Pad1_ Net-_Q13-Pad3_ GND eSim_NPN
R13  Net-_D18-Pad2_ Net-_Q13-Pad3_ 7.2k
R16  Net-_Q13-Pad3_ GND 3k
D24  GND Net-_D24-Pad2_ eSim_Diode
D18  GND Net-_D18-Pad2_ eSim_Diode
D22  Net-_D22-Pad1_ COM eSim_Diode
Q8  Net-_D15-Pad2_ Net-_D11-Pad2_ Net-_Q10-Pad2_ eSim_NPN
Q10  Net-_D13-Pad1_ Net-_Q10-Pad2_ GND eSim_NPN
R8  Net-_D11-Pad2_ Net-_Q10-Pad2_ 7.2k
R10  Net-_Q10-Pad2_ GND 3k
D15  GND Net-_D15-Pad2_ eSim_Diode
D11  GND Net-_D11-Pad2_ eSim_Diode
D13  Net-_D13-Pad1_ COM eSim_Diode
U1  Net-_D2-Pad2_ Net-_D3-Pad2_ Net-_D1-Pad2_ Net-_D11-Pad2_ Net-_D10-Pad2_ Net-_D16-Pad2_ Net-_D17-Pad2_ Net-_D18-Pad2_ GND COM Net-_D24-Pad2_ Net-_D23-Pad2_ Net-_D21-Pad2_ Net-_D14-Pad2_ Net-_D15-Pad2_ Net-_D7-Pad2_ Net-_D9-Pad2_ Net-_D8-Pad2_ PORT

.end
