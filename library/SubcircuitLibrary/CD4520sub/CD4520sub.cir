.title KiCad schematic
U1 Net-_U1-Pad1_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ GND Net-_U1-Pad1_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ GND PORT
U2 Net-_U1-Pad15_ Net-_U2-Pad2_ d_inverter
U4 Net-_U2-Pad2_ Net-_U15-Pad4_ d_inverter
U3 Net-_U1-Pad1_ Net-_U3-Pad2_ d_inverter
U7 Net-_U14-Pad1_ Net-_U5-Pad1_ d_inverter
U5 Net-_U5-Pad1_ Net-_U5-Pad2_ d_inverter
U8 Net-_U8-Pad1_ Net-_U5-Pad2_ unconnected-_U8-Pad3_ Net-_U15-Pad4_ Net-_U10-Pad1_ Net-_U8-Pad1_ d_dff
U6 Net-_U1-Pad10_ Net-_U3-Pad2_ Net-_U14-Pad1_ d_nand
U10 Net-_U10-Pad1_ Net-_U10-Pad2_ d_inverter
U15 Net-_U15-Pad1_ Net-_U12-Pad2_ unconnected-_U15-Pad3_ Net-_U15-Pad4_ Net-_U15-Pad5_ Net-_U15-Pad1_ d_dff
U12 Net-_U12-Pad1_ Net-_U12-Pad2_ d_inverter
U19 Net-_U19-Pad1_ Net-_U19-Pad2_ d_inverter
U17 Net-_U17-Pad1_ Net-_U1-Pad12_ d_inverter
U9 Net-_U10-Pad2_ Net-_U1-Pad11_ d_inverter
U18 Net-_U15-Pad5_ Net-_U17-Pad1_ d_inverter
U22 Net-_U22-Pad1_ Net-_U19-Pad2_ unconnected-_U22-Pad3_ Net-_U15-Pad4_ Net-_U22-Pad5_ Net-_U22-Pad1_ d_dff
U29 Net-_U29-Pad1_ Net-_U29-Pad2_ d_inverter
U28 Net-_U22-Pad5_ Net-_U27-Pad1_ d_inverter
U27 Net-_U27-Pad1_ Net-_U1-Pad13_ d_inverter
U30 Net-_U30-Pad1_ Net-_U29-Pad2_ unconnected-_U30-Pad3_ Net-_U15-Pad4_ Net-_U30-Pad5_ Net-_U30-Pad1_ d_dff
U31 Net-_U31-Pad1_ Net-_U1-Pad14_ d_inverter
U32 Net-_U30-Pad5_ Net-_U31-Pad1_ d_inverter
U20 Net-_U10-Pad2_ Net-_U20-Pad2_ d_inverter
U21 Net-_U14-Pad1_ Net-_U21-Pad2_ d_inverter
X2 Net-_U26-Pad2_ Net-_U25-Pad2_ Net-_U23-Pad2_ Net-_U24-Pad2_ Net-_U29-Pad1_ 4_and
U26 Net-_U22-Pad1_ Net-_U26-Pad2_ d_inverter
U25 Net-_U15-Pad1_ Net-_U25-Pad2_ d_inverter
U24 Net-_U14-Pad1_ Net-_U24-Pad2_ d_inverter
U23 Net-_U10-Pad2_ Net-_U23-Pad2_ d_inverter
U16 Net-_U15-Pad1_ Net-_U16-Pad2_ d_inverter
X1 Net-_U16-Pad2_ Net-_U20-Pad2_ Net-_U21-Pad2_ Net-_U19-Pad1_ 3_and
U14 Net-_U14-Pad1_ Net-_U13-Pad2_ d_inverter
U11 Net-_U10-Pad2_ Net-_U11-Pad2_ d_inverter
U13 Net-_U11-Pad2_ Net-_U13-Pad2_ Net-_U12-Pad1_ d_and
.end
