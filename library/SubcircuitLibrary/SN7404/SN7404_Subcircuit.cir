* C:\FOSSEE\eSim\library\SubcircuitLibrary\SN7404_Subcircuit\SN7404_Subcircuit.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 02/09/25 22:45:10

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
R17  Net-_R1-Pad1_ Net-_Q17-Pad2_ 4k
Q17  Net-_Q17-Pad1_ Net-_Q17-Pad2_ Net-_D9-Pad2_ eSim_NPN
Q19  Net-_Q19-Pad1_ Net-_Q17-Pad1_ Net-_Q19-Pad3_ eSim_NPN
Q21  Net-_Q21-Pad1_ Net-_Q19-Pad1_ Net-_D11-Pad1_ eSim_NPN
D11  Net-_D11-Pad1_ Net-_D11-Pad2_ eSim_Diode
Q22  Net-_D11-Pad2_ Net-_Q19-Pad3_ GNDPWR eSim_NPN
R21  ? Net-_Q19-Pad1_ 1.6k
R23  Net-_R1-Pad1_ Net-_Q21-Pad1_ 130
R19  Net-_Q19-Pad3_ GNDPWR 1k
D9  GNDPWR Net-_D9-Pad2_ eSim_Diode
U1  Net-_D1-Pad2_ Net-_D2-Pad2_ Net-_D3-Pad2_ Net-_D4-Pad2_ Net-_D5-Pad2_ Net-_D6-Pad2_ Net-_R1-Pad1_ GNDPWR Net-_D7-Pad2_ Net-_D8-Pad2_ Net-_D9-Pad2_ Net-_D10-Pad2_ Net-_D11-Pad2_ Net-_D12-Pad2_ PORT
R18  Net-_R1-Pad1_ Net-_Q18-Pad2_ 4k
Q18  Net-_Q18-Pad1_ Net-_Q18-Pad2_ Net-_D10-Pad2_ eSim_NPN
Q20  Net-_Q20-Pad1_ Net-_Q18-Pad1_ Net-_Q20-Pad3_ eSim_NPN
Q23  Net-_Q23-Pad1_ Net-_Q20-Pad1_ Net-_D12-Pad1_ eSim_NPN
D12  Net-_D12-Pad1_ Net-_D12-Pad2_ eSim_Diode
Q24  Net-_D12-Pad2_ Net-_Q20-Pad3_ GNDPWR eSim_NPN
R22  Net-_R1-Pad1_ Net-_Q20-Pad1_ 1.6k
R24  Net-_R1-Pad1_ Net-_Q23-Pad1_ 130
R20  Net-_Q20-Pad3_ GNDPWR 1k
D10  GNDPWR Net-_D10-Pad2_ eSim_Diode
R9  Net-_R1-Pad1_ Net-_Q9-Pad2_ 4k
Q9  Net-_Q11-Pad2_ Net-_Q9-Pad2_ Net-_D5-Pad2_ eSim_NPN
Q11  Net-_Q11-Pad1_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_NPN
Q13  Net-_Q13-Pad1_ Net-_Q11-Pad1_ Net-_D7-Pad1_ eSim_NPN
D7  Net-_D7-Pad1_ Net-_D7-Pad2_ eSim_Diode
Q14  Net-_D7-Pad2_ Net-_Q11-Pad3_ GNDPWR eSim_NPN
R13  ? Net-_Q11-Pad1_ 1.6k
R15  Net-_R1-Pad1_ Net-_Q13-Pad1_ 130
R11  Net-_Q11-Pad3_ GNDPWR 1k
D5  GNDPWR Net-_D5-Pad2_ eSim_Diode
R10  Net-_R1-Pad1_ Net-_Q10-Pad2_ 4k
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_D6-Pad2_ eSim_NPN
Q12  Net-_Q12-Pad1_ Net-_Q10-Pad1_ Net-_Q12-Pad3_ eSim_NPN
Q15  Net-_Q15-Pad1_ Net-_Q12-Pad1_ Net-_D8-Pad1_ eSim_NPN
D8  Net-_D8-Pad1_ Net-_D8-Pad2_ eSim_Diode
Q16  Net-_D8-Pad2_ Net-_Q12-Pad3_ GNDPWR eSim_NPN
R14  ? Net-_Q12-Pad1_ 1.6k
R16  Net-_R1-Pad1_ Net-_Q15-Pad1_ 130
R12  Net-_Q12-Pad3_ GNDPWR 1k
D6  GNDPWR Net-_D6-Pad2_ eSim_Diode
R1  Net-_R1-Pad1_ Net-_Q1-Pad2_ 4k
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_D1-Pad2_ eSim_NPN
Q3  Net-_Q3-Pad1_ Net-_Q1-Pad1_ Net-_Q3-Pad3_ eSim_NPN
Q5  Net-_Q5-Pad1_ Net-_Q3-Pad1_ Net-_D3-Pad1_ eSim_NPN
D3  Net-_D3-Pad1_ Net-_D3-Pad2_ eSim_Diode
Q6  Net-_D3-Pad2_ Net-_Q3-Pad3_ GNDPWR eSim_NPN
R5  ? Net-_Q3-Pad1_ 1.6k
R7  Net-_R1-Pad1_ Net-_Q5-Pad1_ 130
R3  Net-_Q3-Pad3_ GNDPWR 1k
D1  GNDPWR Net-_D1-Pad2_ eSim_Diode
R2  Net-_R1-Pad1_ Net-_Q2-Pad2_ 4k
Q2  Net-_Q2-Pad1_ Net-_Q2-Pad2_ Net-_D2-Pad2_ eSim_NPN
Q4  Net-_Q4-Pad1_ Net-_Q2-Pad1_ Net-_Q4-Pad3_ eSim_NPN
Q7  Net-_Q7-Pad1_ Net-_Q4-Pad1_ Net-_D4-Pad1_ eSim_NPN
D4  Net-_D4-Pad1_ Net-_D4-Pad2_ eSim_Diode
Q8  Net-_D4-Pad2_ Net-_Q4-Pad3_ GNDPWR eSim_NPN
R6  ? Net-_Q4-Pad1_ 1.6k
R8  Net-_R1-Pad1_ Net-_Q7-Pad1_ 130
R4  Net-_Q4-Pad3_ GNDPWR 1k
D2  GNDPWR Net-_D2-Pad2_ eSim_Diode

.end
