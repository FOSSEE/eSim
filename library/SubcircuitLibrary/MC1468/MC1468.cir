.title KiCad schematic
Q1 Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
U2 GND Net-_Q1-Pad2_ zener
R3 Net-_Q7-Pad3_ Net-_Q1-Pad3_ 22k
Q6 Net-_Q1-Pad1_ Net-_Q6-Pad2_ Net-_Q1-Pad3_ eSim_NPN
U1 Net-_Q10-Pad1_ Net-_Q8-Pad3_ Net-_Q11-Pad3_ Net-_Q11-Pad1_ Net-_Q14-Pad1_ Net-_Q22-Pad3_ Net-_R8-Pad1_ Net-_Q15-Pad1_ Net-_Q6-Pad2_ Net-_Q7-Pad2_ PORT
Q4 Net-_Q16-Pad2_ Net-_Q16-Pad2_ Net-_Q14-Pad1_ eSim_NPN
Q7 Net-_Q16-Pad2_ Net-_Q7-Pad2_ Net-_Q7-Pad3_ eSim_PNP
Q3 Net-_Q16-Pad2_ Net-_Q16-Pad2_ Net-_Q14-Pad1_ eSim_NPN
R1 Net-_Q1-Pad2_ Net-_Q11-Pad1_ 100k
Q2 Net-_Q1-Pad1_ Net-_Q1-Pad1_ Net-_Q2-Pad3_ eSim_PNP
R2 Net-_Q2-Pad3_ Net-_Q11-Pad1_ 1k
R9 Net-_Q14-Pad1_ Net-_Q24-Pad3_ 9k
Q22 Net-_Q22-Pad1_ Net-_Q15-Pad1_ Net-_Q22-Pad3_ eSim_PNP
Q23 Net-_Q15-Pad1_ Net-_Q22-Pad3_ Net-_Q23-Pad3_ eSim_PNP
Q20 Net-_Q18-Pad3_ Net-_Q16-Pad2_ Net-_Q14-Pad1_ eSim_NPN
Q19 Net-_Q18-Pad3_ Net-_Q16-Pad2_ Net-_Q14-Pad1_ eSim_NPN
Q24 Net-_Q22-Pad3_ Net-_Q22-Pad1_ Net-_Q24-Pad3_ eSim_NPN
R8 Net-_R8-Pad1_ Net-_Q23-Pad3_ 200
Q16 Net-_Q15-Pad1_ Net-_Q16-Pad2_ Net-_Q14-Pad1_ eSim_NPN
R7 Net-_Q18-Pad2_ GND 2k
Q18 Net-_Q14-Pad2_ Net-_Q18-Pad2_ Net-_Q18-Pad3_ eSim_NPN
Q15 Net-_Q15-Pad1_ GND Net-_Q12-Pad1_ eSim_PNP
Q10 Net-_Q10-Pad1_ Net-_Q10-Pad2_ GND eSim_NPN
R6 GND Net-_Q10-Pad2_ 1k
U4 Net-_Q10-Pad2_ Net-_Q6-Pad2_ zener
U3 Net-_R5-Pad2_ Net-_Q8-Pad3_ zener
R5 Net-_Q6-Pad2_ Net-_R5-Pad2_ 1.4k
Q11 Net-_Q11-Pad1_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_NPN
Q25 Net-_Q22-Pad3_ Net-_Q24-Pad3_ Net-_Q14-Pad1_ eSim_NPN
U8 Net-_R8-Pad1_ Net-_R11-Pad1_ zener
R10 Net-_Q21-Pad2_ Net-_R10-Pad2_ 4k
U6 Net-_R10-Pad2_ Net-_U5-PadIN_ zener
U5 Net-_U5-PadIN_ Net-_Q8-Pad3_ zener
U7 Net-_R11-Pad2_ Net-_Q21-Pad2_ zener
R11 Net-_R11-Pad1_ Net-_R11-Pad2_ 4k
Q14 Net-_Q14-Pad1_ Net-_Q14-Pad2_ Net-_Q12-Pad2_ eSim_PNP
Q21 Net-_Q12-Pad1_ Net-_Q21-Pad2_ Net-_Q18-Pad3_ eSim_NPN
Q13 Net-_Q12-Pad1_ Net-_Q12-Pad2_ Net-_Q11-Pad2_ eSim_PNP
Q17 Net-_Q14-Pad2_ Net-_Q12-Pad2_ Net-_Q11-Pad2_ eSim_PNP
Q12 Net-_Q12-Pad1_ Net-_Q12-Pad2_ Net-_Q11-Pad2_ eSim_PNP
Q9 Net-_Q11-Pad1_ Net-_Q10-Pad1_ Net-_Q11-Pad2_ eSim_NPN
Q8 Net-_Q10-Pad1_ Net-_Q11-Pad3_ Net-_Q8-Pad3_ eSim_NPN
Q5 Net-_Q10-Pad1_ Net-_Q1-Pad1_ Net-_Q5-Pad3_ eSim_PNP
R4 Net-_Q5-Pad3_ Net-_Q11-Pad1_ 1k
.end
