.title KiCad schematic
Q16 Net-_Q12-Pad2_ Net-_J1-Pad3_ Net-_J1-Pad2_ eSim_NPN
J1 Net-_C1-Pad1_ Net-_J1-Pad2_ Net-_J1-Pad3_ eSim_NJF
R7 Net-_Q12-Pad2_ Net-_J1-Pad3_ 180
Q12 Net-_Q11-Pad3_ Net-_Q12-Pad2_ Net-_J1-Pad2_ eSim_NPN
U1 Net-_R3-Pad1_ Net-_R5-Pad1_ Net-_R2-Pad1_ Net-_R1-Pad1_ Net-_J1-Pad2_ Net-_Q33-Pad3_ Net-_C1-Pad1_ Net-_R21-Pad1_ Net-_R23-Pad1_ Net-_R20-Pad1_ Net-_R19-Pad1_ Net-_J2-Pad2_ Net-_Q69-Pad3_ Net-_C5-Pad1_ PORT
Q18 Net-_Q15-Pad2_ Net-_Q12-Pad2_ Net-_J1-Pad2_ eSim_NPN
Q19 Net-_Q19-Pad1_ Net-_Q12-Pad2_ Net-_J1-Pad2_ eSim_NPN
Q3 Net-_C2-Pad1_ Net-_D5-Pad1_ Net-_Q3-Pad3_ eSim_NPN
Q4 Net-_Q3-Pad3_ Net-_Q1-Pad2_ Net-_Q4-Pad3_ eSim_NPN
Q2 Net-_Q1-Pad2_ Net-_Q1-Pad2_ Net-_D5-Pad1_ eSim_PNP
Q1 Net-_D1-Pad1_ Net-_Q1-Pad2_ Net-_D5-Pad1_ eSim_PNP
R4 Net-_C2-Pad1_ Net-_R3-Pad1_ 40k
R3 Net-_R3-Pad1_ Net-_C1-Pad1_ 6k
R6 Net-_C1-Pad2_ Net-_R5-Pad1_ 40k
Q6 Net-_Q4-Pad3_ Net-_D1-Pad1_ Net-_Q11-Pad3_ eSim_NPN
R5 Net-_R5-Pad1_ Net-_C1-Pad1_ 6k
Q15 Net-_D5-Pad1_ Net-_Q15-Pad2_ Net-_C1-Pad1_ eSim_PNP
C1 Net-_C1-Pad1_ Net-_C1-Pad2_ 0.1u
Q7 Net-_J1-Pad2_ Net-_Q11-Pad3_ Net-_D6-Pad2_ eSim_PNP
D1 Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
D3 Net-_D3-Pad1_ Net-_D1-Pad1_ eSim_Diode
Q5 Net-_Q4-Pad3_ Net-_D1-Pad1_ Net-_Q11-Pad3_ eSim_NPN
R2 Net-_R2-Pad1_ Net-_D2-Pad2_ 500
R1 Net-_R1-Pad1_ Net-_D1-Pad1_ 500
D2 Net-_D1-Pad2_ Net-_D2-Pad2_ eSim_Diode
D4 Net-_D2-Pad2_ Net-_D3-Pad1_ eSim_Diode
Q10 Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
D5 Net-_D5-Pad1_ Net-_D5-Pad2_ eSim_Diode
Q9 Net-_C1-Pad2_ Net-_D5-Pad1_ Net-_Q10-Pad1_ eSim_NPN
Q8 Net-_Q10-Pad3_ Net-_D2-Pad2_ Net-_Q11-Pad3_ eSim_NPN
D6 Net-_D5-Pad2_ Net-_D6-Pad2_ eSim_Diode
Q11 Net-_Q10-Pad3_ Net-_D2-Pad2_ Net-_Q11-Pad3_ eSim_NPN
Q17 Net-_Q15-Pad2_ Net-_Q15-Pad2_ Net-_C1-Pad1_ eSim_PNP
Q14 Net-_D2-Pad2_ Net-_Q10-Pad2_ Net-_D5-Pad1_ eSim_PNP
Q13 Net-_Q10-Pad2_ Net-_Q10-Pad2_ Net-_D5-Pad1_ eSim_PNP
R9 Net-_J1-Pad2_ Net-_Q23-Pad3_ 2k
Q23 Net-_Q23-Pad1_ Net-_D7-Pad1_ Net-_Q23-Pad3_ eSim_NPN
D7 Net-_D7-Pad1_ Net-_D7-Pad2_ eSim_Diode
R8 Net-_J1-Pad2_ Net-_D7-Pad2_ 2k
Q25 Net-_Q24-Pad2_ Net-_Q12-Pad2_ Net-_J1-Pad2_ eSim_NPN
Q20 Net-_C1-Pad1_ Net-_C2-Pad1_ Net-_Q19-Pad1_ eSim_NPN
Q21 Net-_D7-Pad1_ Net-_Q19-Pad1_ Net-_Q21-Pad3_ eSim_PNP
Q24 Net-_Q23-Pad1_ Net-_Q24-Pad2_ Net-_Q21-Pad3_ eSim_PNP
Q26 Net-_C1-Pad1_ Net-_C1-Pad2_ Net-_Q24-Pad2_ eSim_NPN
C3 Net-_C2-Pad1_ Net-_C3-Pad2_ 30p
C2 Net-_C2-Pad1_ Net-_C2-Pad2_ 55p
Q22 Net-_Q21-Pad3_ Net-_Q15-Pad2_ Net-_C1-Pad1_ eSim_PNP
R10 Net-_Q23-Pad1_ Net-_C3-Pad2_ 3k
C4 Net-_C3-Pad2_ Net-_C4-Pad2_ 20p
R11 Net-_C2-Pad2_ Net-_C4-Pad2_ 3k
Q31 Net-_C1-Pad1_ Net-_Q28-Pad1_ Net-_D9-Pad1_ eSim_NPN
Q28 Net-_Q28-Pad1_ Net-_Q15-Pad2_ Net-_C1-Pad1_ eSim_PNP
R14 Net-_C4-Pad2_ Net-_C1-Pad1_ 25k
R13 Net-_C4-Pad2_ Net-_Q28-Pad1_ 1.5k
R12 Net-_J1-Pad2_ Net-_D8-Pad2_ 8k
Q29 Net-_C4-Pad2_ Net-_D8-Pad1_ Net-_Q23-Pad1_ eSim_NPN
D8 Net-_D8-Pad1_ Net-_D8-Pad2_ eSim_Diode
R16 Net-_J1-Pad2_ Net-_Q32-Pad3_ 240
Q27 Net-_C1-Pad1_ Net-_Q23-Pad1_ Net-_D8-Pad1_ eSim_NPN
Q30 Net-_C4-Pad2_ Net-_D8-Pad1_ Net-_Q30-Pad3_ eSim_NPN
Q32 Net-_D9-Pad2_ Net-_D8-Pad1_ Net-_Q32-Pad3_ eSim_NPN
R15 Net-_J1-Pad2_ Net-_Q30-Pad3_ 120
R18 Net-_Q33-Pad3_ Net-_Q33-Pad2_ 20
R17 Net-_Q34-Pad2_ Net-_Q33-Pad3_ 20
Q36 Net-_C1-Pad1_ Net-_C4-Pad2_ Net-_Q33-Pad2_ eSim_NPN
Q34 Net-_D9-Pad2_ Net-_Q34-Pad2_ Net-_Q33-Pad3_ eSim_PNP
D9 Net-_D9-Pad1_ Net-_D9-Pad2_ eSim_Diode
Q33 Net-_C4-Pad2_ Net-_Q33-Pad2_ Net-_Q33-Pad3_ eSim_NPN
Q35 Net-_J1-Pad2_ Net-_D9-Pad2_ Net-_Q34-Pad2_ eSim_PNP
Q46 Net-_Q45-Pad3_ Net-_Q46-Pad2_ Net-_Q44-Pad1_ eSim_NPN
Q55 Net-_Q55-Pad1_ Net-_Q48-Pad2_ Net-_J2-Pad2_ eSim_NPN
Q54 Net-_Q51-Pad2_ Net-_Q48-Pad2_ Net-_J2-Pad2_ eSim_NPN
R25 Net-_Q48-Pad2_ Net-_J2-Pad3_ 180
J2 Net-_C5-Pad1_ Net-_J2-Pad2_ Net-_J2-Pad3_ eSim_NJF
Q52 Net-_Q48-Pad2_ Net-_J2-Pad3_ Net-_J2-Pad2_ eSim_NPN
D12 Net-_D12-Pad1_ Net-_D10-Pad1_ eSim_Diode
D11 Net-_D10-Pad2_ Net-_D11-Pad2_ eSim_Diode
D13 Net-_D11-Pad2_ Net-_D12-Pad1_ eSim_Diode
D10 Net-_D10-Pad1_ Net-_D10-Pad2_ eSim_Diode
R20 Net-_R20-Pad1_ Net-_D11-Pad2_ 500
R19 Net-_R19-Pad1_ Net-_D10-Pad1_ 500
D14 Net-_D14-Pad1_ Net-_D14-Pad2_ eSim_Diode
Q45 Net-_C5-Pad2_ Net-_D14-Pad1_ Net-_Q45-Pad3_ eSim_NPN
R22 Net-_C6-Pad1_ Net-_R21-Pad1_ 40k
Q39 Net-_C6-Pad1_ Net-_D14-Pad1_ Net-_Q39-Pad3_ eSim_NPN
R21 Net-_R21-Pad1_ Net-_C5-Pad1_ 6k
R23 Net-_R23-Pad1_ Net-_C5-Pad1_ 6k
R24 Net-_C5-Pad2_ Net-_R23-Pad1_ 40k
Q51 Net-_D14-Pad1_ Net-_Q51-Pad2_ Net-_C5-Pad1_ eSim_PNP
C5 Net-_C5-Pad1_ Net-_C5-Pad2_ 0.1u
Q44 Net-_Q44-Pad1_ Net-_D11-Pad2_ Net-_Q41-Pad3_ eSim_NPN
Q42 Net-_Q40-Pad3_ Net-_D10-Pad1_ Net-_Q41-Pad3_ eSim_NPN
D15 Net-_D14-Pad2_ Net-_D15-Pad2_ eSim_Diode
Q43 Net-_J2-Pad2_ Net-_Q41-Pad3_ Net-_D15-Pad2_ eSim_PNP
Q48 Net-_Q41-Pad3_ Net-_Q48-Pad2_ Net-_J2-Pad2_ eSim_NPN
Q41 Net-_Q40-Pad3_ Net-_D10-Pad1_ Net-_Q41-Pad3_ eSim_NPN
Q47 Net-_Q44-Pad1_ Net-_D11-Pad2_ Net-_Q41-Pad3_ eSim_NPN
Q40 Net-_Q39-Pad3_ Net-_Q37-Pad2_ Net-_Q40-Pad3_ eSim_NPN
Q38 Net-_Q37-Pad2_ Net-_Q37-Pad2_ Net-_D14-Pad1_ eSim_PNP
Q37 Net-_D10-Pad1_ Net-_Q37-Pad2_ Net-_D14-Pad1_ eSim_PNP
Q53 Net-_Q51-Pad2_ Net-_Q51-Pad2_ Net-_C5-Pad1_ eSim_PNP
C6 Net-_C6-Pad1_ Net-_C6-Pad2_ 55p
Q50 Net-_D11-Pad2_ Net-_Q46-Pad2_ Net-_D14-Pad1_ eSim_PNP
Q49 Net-_Q46-Pad2_ Net-_Q46-Pad2_ Net-_D14-Pad1_ eSim_PNP
Q57 Net-_D16-Pad1_ Net-_Q55-Pad1_ Net-_Q57-Pad3_ eSim_PNP
Q60 Net-_Q59-Pad1_ Net-_Q60-Pad2_ Net-_Q57-Pad3_ eSim_PNP
Q56 Net-_C5-Pad1_ Net-_C6-Pad1_ Net-_Q55-Pad1_ eSim_NPN
C7 Net-_C6-Pad1_ Net-_C7-Pad2_ 30p
Q58 Net-_Q57-Pad3_ Net-_Q51-Pad2_ Net-_C5-Pad1_ eSim_PNP
Q62 Net-_C5-Pad1_ Net-_C5-Pad2_ Net-_Q60-Pad2_ eSim_NPN
R33 Net-_J2-Pad2_ Net-_Q66-Pad3_ 120
Q61 Net-_Q60-Pad2_ Net-_Q48-Pad2_ Net-_J2-Pad2_ eSim_NPN
R30 Net-_J2-Pad2_ Net-_D17-Pad2_ 8k
Q66 Net-_C8-Pad2_ Net-_D17-Pad1_ Net-_Q66-Pad3_ eSim_NPN
R34 Net-_J2-Pad2_ Net-_Q68-Pad3_ 240
Q68 Net-_D18-Pad2_ Net-_D17-Pad1_ Net-_Q68-Pad3_ eSim_NPN
Q65 Net-_C8-Pad2_ Net-_D17-Pad1_ Net-_Q59-Pad1_ eSim_NPN
D17 Net-_D17-Pad1_ Net-_D17-Pad2_ eSim_Diode
Q71 Net-_J2-Pad2_ Net-_D18-Pad2_ Net-_Q70-Pad2_ eSim_PNP
R35 Net-_Q70-Pad2_ Net-_Q69-Pad3_ 20
Q69 Net-_C8-Pad2_ Net-_Q69-Pad2_ Net-_Q69-Pad3_ eSim_NPN
D18 Net-_D18-Pad1_ Net-_D18-Pad2_ eSim_Diode
Q70 Net-_D18-Pad2_ Net-_Q70-Pad2_ Net-_Q69-Pad3_ eSim_PNP
C8 Net-_C7-Pad2_ Net-_C8-Pad2_ 20p
R36 Net-_Q69-Pad3_ Net-_Q69-Pad2_ 20
Q72 Net-_C5-Pad1_ Net-_C8-Pad2_ Net-_Q69-Pad2_ eSim_NPN
Q63 Net-_C5-Pad1_ Net-_Q59-Pad1_ Net-_D17-Pad1_ eSim_NPN
Q67 Net-_C5-Pad1_ Net-_Q64-Pad1_ Net-_D18-Pad1_ eSim_NPN
R32 Net-_C8-Pad2_ Net-_C5-Pad1_ 25k
Q64 Net-_Q64-Pad1_ Net-_Q51-Pad2_ Net-_C5-Pad1_ eSim_PNP
R29 Net-_C6-Pad2_ Net-_C8-Pad2_ 3k
R31 Net-_C8-Pad2_ Net-_Q64-Pad1_ 1.5k
D16 Net-_D16-Pad1_ Net-_D16-Pad2_ eSim_Diode
R26 Net-_J2-Pad2_ Net-_D16-Pad2_ 2k
R27 Net-_J2-Pad2_ Net-_Q59-Pad3_ 2k
R28 Net-_Q59-Pad1_ Net-_C7-Pad2_ 3k
Q59 Net-_Q59-Pad1_ Net-_D16-Pad1_ Net-_Q59-Pad3_ eSim_NPN
.end
