.title KiCad schematic
U1 Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ GND Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ GND PORT
X4 Net-_U1-Pad1_ Net-_U2-Pad2_ Net-_U7-Pad2_ Net-_U8-Pad2_ Net-_U6-Pad2_ Net-_U11-Pad2_ 5_and
X3 Net-_U1-Pad2_ Net-_U2-Pad2_ Net-_U7-Pad2_ Net-_U3-Pad2_ Net-_U6-Pad2_ Net-_U11-Pad1_ 5_and
X1 Net-_U1-Pad4_ Net-_U2-Pad2_ Net-_U4-Pad2_ Net-_U3-Pad2_ Net-_U6-Pad2_ Net-_U9-Pad1_ 5_and
X2 Net-_U1-Pad3_ Net-_U2-Pad2_ Net-_U4-Pad2_ Net-_U8-Pad2_ Net-_U6-Pad2_ Net-_U9-Pad2_ 5_and
U9 Net-_U9-Pad1_ Net-_U9-Pad2_ Net-_U10-Pad1_ d_nor
U10 Net-_U10-Pad1_ Net-_U10-Pad2_ Net-_U10-Pad3_ d_nor
U11 Net-_U11-Pad1_ Net-_U11-Pad2_ Net-_U10-Pad2_ d_nor
U12 Net-_U1-Pad6_ Net-_U1-Pad5_ d_inverter
X5 Net-_U1-Pad15_ Net-_U4-Pad2_ Net-_U5-Pad2_ Net-_U3-Pad2_ Net-_U6-Pad2_ Net-_U14-Pad1_ 5_and
X6 Net-_U1-Pad14_ Net-_U4-Pad2_ Net-_U8-Pad2_ Net-_U5-Pad2_ Net-_U6-Pad2_ Net-_U14-Pad2_ 5_and
U14 Net-_U14-Pad1_ Net-_U14-Pad2_ Net-_U14-Pad3_ d_nor
U15 Net-_U14-Pad3_ Net-_U15-Pad2_ Net-_U13-Pad2_ d_nor
U16 Net-_U16-Pad1_ Net-_U16-Pad2_ Net-_U15-Pad2_ d_nor
U13 Net-_U10-Pad3_ Net-_U13-Pad2_ Net-_U1-Pad6_ d_nor
U7 Net-_U4-Pad2_ Net-_U7-Pad2_ d_inverter
U6 Net-_U1-Pad7_ Net-_U6-Pad2_ d_inverter
U8 Net-_U3-Pad2_ Net-_U8-Pad2_ d_inverter
U5 Net-_U2-Pad2_ Net-_U5-Pad2_ d_inverter
U3 Net-_U1-Pad11_ Net-_U3-Pad2_ d_inverter
U2 Net-_U1-Pad9_ Net-_U2-Pad2_ d_inverter
U4 Net-_U1-Pad10_ Net-_U4-Pad2_ d_inverter
X7 Net-_U1-Pad13_ Net-_U7-Pad2_ Net-_U5-Pad2_ Net-_U3-Pad2_ Net-_U6-Pad2_ Net-_U16-Pad1_ 5_and
X8 Net-_U1-Pad12_ Net-_U7-Pad2_ Net-_U8-Pad2_ Net-_U5-Pad2_ Net-_U6-Pad2_ Net-_U16-Pad2_ 5_and
.end
