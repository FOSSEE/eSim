* D:\FOSSEE\eSim\library\SubcircuitLibrary\LM78M05_IC\LM78M05_IC.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 07/02/24 21:24:07

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
R1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ 80k
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
U1  Net-_Q16-Pad3_ Net-_Q1-Pad2_ zener
R2  Net-_Q1-Pad3_ Net-_Q13-Pad2_ 7k
R3  Net-_Q13-Pad2_ Net-_Q3-Pad2_ 4.97k
R4  Net-_Q3-Pad2_ Net-_Q16-Pad3_ 830
Q4  Net-_Q2-Pad1_ Net-_Q2-Pad1_ Net-_Q1-Pad1_ eSim_PNP
Q8  Net-_Q12-Pad1_ Net-_Q2-Pad1_ Net-_Q1-Pad1_ eSim_PNP
Q5  Net-_Q2-Pad1_ Net-_Q1-Pad3_ Net-_Q5-Pad3_ eSim_NPN
Q2  Net-_Q2-Pad1_ Net-_Q13-Pad2_ Net-_Q2-Pad3_ eSim_NPN
Q6  Net-_Q5-Pad3_ Net-_Q13-Pad2_ Net-_Q6-Pad3_ eSim_NPN
R5  Net-_Q2-Pad3_ Net-_Q6-Pad3_ 500
Q7  Net-_Q6-Pad3_ Net-_Q7-Pad2_ Net-_C1-Pad2_ eSim_NPN
R6  Net-_C1-Pad2_ Net-_Q16-Pad3_ 1.2k
R7  Net-_Q6-Pad3_ Net-_Q7-Pad2_ 1.9k
R8  Net-_Q7-Pad2_ Net-_C1-Pad1_ 26
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 0.4p
Q9  Net-_C1-Pad1_ Net-_C1-Pad2_ Net-_Q16-Pad3_ eSim_NPN
U2  Net-_R12-Pad1_ Net-_Q1-Pad1_ zener
R12  Net-_R12-Pad1_ Net-_R12-Pad2_ 5k
U3  Net-_Q12-Pad2_ Net-_R12-Pad2_ zener
Q18  Net-_Q1-Pad1_ Net-_Q12-Pad1_ Net-_Q13-Pad1_ eSim_NPN
Q19  Net-_Q1-Pad1_ Net-_Q13-Pad1_ Net-_Q19-Pad3_ eSim_NPN
R18  Net-_Q13-Pad1_ Net-_Q12-Pad2_ 1.14k
Q12  Net-_Q12-Pad1_ Net-_Q12-Pad2_ Net-_Q12-Pad3_ eSim_NPN
R16  Net-_Q19-Pad3_ Net-_Q12-Pad2_ 100
R17  Net-_R17-Pad1_ Net-_Q12-Pad3_ 100
R19  Net-_R17-Pad1_ Net-_Q19-Pad3_ 0.5
Q13  Net-_Q13-Pad1_ Net-_Q13-Pad2_ Net-_Q10-Pad1_ eSim_NPN
R20  Net-_Q13-Pad2_ Net-_R17-Pad1_ 1.6k
R14  Net-_Q17-Pad3_ Net-_Q12-Pad1_ 850
R10  Net-_C2-Pad2_ Net-_Q10-Pad1_ 16.5k
Q10  Net-_Q10-Pad1_ Net-_C1-Pad1_ Net-_Q10-Pad3_ eSim_NPN
R9  Net-_Q16-Pad3_ Net-_Q10-Pad3_ 12.1k
R15  Net-_C2-Pad1_ Net-_Q17-Pad3_ 4k
C2  Net-_C2-Pad1_ Net-_C2-Pad2_ 20p
Q14  Net-_C2-Pad1_ Net-_C2-Pad2_ Net-_Q14-Pad3_ eSim_NPN
Q3  Net-_Q12-Pad1_ Net-_Q3-Pad2_ Net-_Q16-Pad3_ eSim_NPN
Q11  Net-_C2-Pad2_ Net-_Q10-Pad3_ Net-_Q11-Pad3_ eSim_NPN
R11  Net-_Q16-Pad3_ Net-_Q11-Pad3_ 1k
Q15  Net-_Q14-Pad3_ Net-_Q14-Pad3_ Net-_Q15-Pad3_ eSim_NPN
R13  Net-_Q16-Pad3_ Net-_Q15-Pad3_ 4k
Q16  Net-_C2-Pad1_ Net-_Q14-Pad3_ Net-_Q16-Pad3_ eSim_NPN
R21  Net-_Q16-Pad3_ Net-_Q13-Pad2_ 4k
Q17  Net-_Q16-Pad3_ Net-_C2-Pad1_ Net-_Q17-Pad3_ eSim_PNP
U4  Net-_Q1-Pad1_ Net-_R17-Pad1_ Net-_Q16-Pad3_ PORT

.end
