* C:\FOSSEE\eSim\library\SubcircuitLibrary\LM342\LM342.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/10/24 17:45:07

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
J1  Net-_J1-Pad1_ GND Net-_J1-Pad3_ jfet_n
R1  Net-_J1-Pad1_ Net-_Q2-Pad3_ 418
Q2  Net-_Q1-Pad3_ Net-_Q1-Pad1_ Net-_Q2-Pad3_ eSim_PNP
Q3  Net-_Q1-Pad1_ Net-_Q1-Pad1_ Net-_J1-Pad1_ eSim_PNP
Q8  Net-_Q12-Pad3_ Net-_Q1-Pad1_ Net-_J1-Pad1_ eSim_PNP
Q1  Net-_Q1-Pad1_ Net-_J1-Pad3_ Net-_Q1-Pad3_ eSim_NPN
Q4  Net-_Q1-Pad1_ Net-_Q1-Pad3_ Net-_Q4-Pad3_ eSim_NPN
R2  Net-_Q4-Pad3_ Net-_Q7-Pad2_ 576
R3  Net-_Q7-Pad2_ Net-_R3-Pad2_ 3.41k
Q7  Net-_Q7-Pad1_ Net-_Q7-Pad2_ Net-_Q4-Pad3_ eSim_PNP
U1  GND Net-_J1-Pad3_ zener
U2  GND Net-_Q1-Pad3_ zener
R4  Net-_R3-Pad2_ Net-_Q11-Pad2_ 3.89k
R5  Net-_Q7-Pad1_ GND 7.8k
Q9  Net-_Q12-Pad3_ Net-_Q7-Pad1_ GND eSim_NPN
R6  Net-_Q10-Pad2_ Net-_R3-Pad2_ 13k
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
Q5  Net-_Q11-Pad2_ Net-_Q11-Pad2_ Net-_Q5-Pad3_ eSim_NPN
Q6  Net-_Q5-Pad3_ Net-_Q5-Pad3_ GND eSim_NPN
Q11  Net-_Q10-Pad3_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_NPN
R7  Net-_Q11-Pad3_ GND 2.84k
Q12  GND Net-_C1-Pad2_ Net-_Q12-Pad3_ eSim_PNP
Q13  Net-_C1-Pad2_ Net-_C1-Pad1_ Net-_Q10-Pad3_ eSim_NPN
R8  Net-_C1-Pad2_ Net-_Q12-Pad3_ 5.76k
Q14  Net-_Q12-Pad3_ Net-_Q14-Pad2_ Net-_Q14-Pad3_ eSim_NPN
R9  Net-_R13-Pad1_ Net-_Q14-Pad3_ 100
Q15  Net-_J1-Pad1_ Net-_Q12-Pad3_ Net-_Q10-Pad1_ eSim_NPN
U4  Net-_Q14-Pad2_ Net-_R10-Pad1_ zener
R10  Net-_R10-Pad1_ Net-_R10-Pad2_ 5k
U3  Net-_R10-Pad2_ Net-_J1-Pad1_ zener
Q16  Net-_J1-Pad1_ Net-_Q10-Pad1_ Net-_Q16-Pad3_ eSim_NPN
R13  Net-_R13-Pad1_ Net-_Q10-Pad1_ 2.5k
R15  Net-_R13-Pad1_ Net-_Q16-Pad3_ 1.9
R11  Net-_Q14-Pad2_ Net-_Q16-Pad3_ 100
R16  Net-_R12-Pad2_ Net-_R13-Pad1_ 1.4K
R12  Net-_C1-Pad1_ Net-_R12-Pad2_ 15k
R14  Net-_R12-Pad2_ GND 2.23k
U5  Net-_J1-Pad1_ Net-_R13-Pad1_ GND PORT
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 5pF

.end
