* D:\FOSSEE\eSim\library\SubcircuitLibrary\sn74ls09__\sn74ls09__.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 02/17/25 00:06:42

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
R1  Net-_R1-Pad1_ Net-_Q4-Pad2_ 20k
R2  Net-_R1-Pad1_ Net-_Q1-Pad2_ 10k
R3  Net-_R1-Pad1_ Net-_Q1-Pad1_ 8k
R7  Net-_Q1-Pad3_ GNDPWR 5k
D1  Net-_D1-Pad1_ GNDPWR eSim_Diode
U6  GNDPWR Net-_U1-Pad7_ zener
U7  GNDPWR Net-_U1-Pad4_ zener
U2  Net-_Q4-Pad2_ Net-_U1-Pad4_ zener
U4  Net-_Q4-Pad2_ Net-_U1-Pad7_ zener
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
Q4  Net-_Q1-Pad2_ Net-_Q4-Pad2_ Net-_D1-Pad1_ eSim_NPN
Q2  Net-_Q2-Pad1_ Net-_Q1-Pad3_ GNDPWR eSim_NPN
U1  Net-_R1-Pad1_ GNDPWR Net-_Q2-Pad1_ Net-_U1-Pad4_ Net-_Q5-Pad1_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_Q8-Pad1_ Net-_U1-Pad10_ Net-_Q11-Pad1_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ PORT
R9  Net-_R1-Pad1_ Net-_Q10-Pad2_ 20k
R10  Net-_R1-Pad1_ Net-_Q10-Pad1_ 10k
R11  Net-_R1-Pad1_ Net-_Q7-Pad1_ 8k
R15  Net-_Q7-Pad3_ GNDPWR 5k
D3  Net-_D3-Pad1_ GNDPWR eSim_Diode
U14  GNDPWR Net-_U1-Pad13_ zener
U15  GNDPWR Net-_U1-Pad10_ zener
U10  Net-_Q10-Pad2_ Net-_U1-Pad10_ zener
U12  Net-_Q10-Pad2_ Net-_U1-Pad13_ zener
Q7  Net-_Q7-Pad1_ Net-_Q10-Pad1_ Net-_Q7-Pad3_ eSim_NPN
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_D3-Pad1_ eSim_NPN
Q8  Net-_Q8-Pad1_ Net-_Q7-Pad3_ GNDPWR eSim_NPN
R6  Net-_R1-Pad1_ Net-_Q6-Pad2_ 20k
R5  Net-_R1-Pad1_ Net-_Q3-Pad2_ 10k
R4  Net-_R1-Pad1_ Net-_Q3-Pad1_ 8k
R8  Net-_Q3-Pad3_ GNDPWR 5k
D2  Net-_D2-Pad1_ GNDPWR eSim_Diode
U8  GNDPWR Net-_U1-Pad8_ zener
U9  GNDPWR Net-_U1-Pad6_ zener
U3  Net-_Q6-Pad2_ Net-_U1-Pad6_ zener
U5  Net-_Q6-Pad2_ Net-_U1-Pad8_ zener
Q3  Net-_Q3-Pad1_ Net-_Q3-Pad2_ Net-_Q3-Pad3_ eSim_NPN
Q6  Net-_Q3-Pad2_ Net-_Q6-Pad2_ Net-_D2-Pad1_ eSim_NPN
Q5  Net-_Q5-Pad1_ Net-_Q3-Pad3_ GNDPWR eSim_NPN
R14  Net-_R1-Pad1_ Net-_Q12-Pad2_ 20k
R13  Net-_R1-Pad1_ Net-_Q12-Pad1_ 10k
R12  Net-_R1-Pad1_ Net-_Q9-Pad1_ 8k
R16  Net-_Q11-Pad2_ GNDPWR 5k
D4  Net-_D4-Pad1_ GNDPWR eSim_Diode
U16  GNDPWR Net-_U1-Pad14_ zener
U17  GNDPWR Net-_U1-Pad12_ zener
U11  Net-_Q12-Pad2_ Net-_U1-Pad12_ zener
U13  Net-_Q12-Pad2_ Net-_U1-Pad14_ zener
Q9  Net-_Q9-Pad1_ Net-_Q12-Pad1_ Net-_Q11-Pad2_ eSim_NPN
Q12  Net-_Q12-Pad1_ Net-_Q12-Pad2_ Net-_D4-Pad1_ eSim_NPN
Q11  Net-_Q11-Pad1_ Net-_Q11-Pad2_ GNDPWR eSim_NPN

.end
