* C:\FOSSEE\eSim\library\SubcircuitLibrary\7447\7447.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 05/03/25 19:04:33

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U3  Net-_U1-Pad1_ Net-_U1-Pad6_ Net-_U10-Pad1_ d_nand
U4  Net-_U1-Pad2_ Net-_U1-Pad6_ Net-_U11-Pad1_ d_nand
U5  Net-_U1-Pad3_ Net-_U1-Pad6_ Net-_U12-Pad1_ d_nand
U2  Net-_U1-Pad4_ Net-_U13-Pad1_ d_inverter
U6  Net-_U1-Pad7_ Net-_U6-Pad2_ d_inverter
X1  Net-_U1-Pad6_ Net-_U6-Pad2_ Net-_U11-Pad1_ Net-_U12-Pad1_ Net-_U33-Pad1_ 4_and
U9  Net-_U13-Pad1_ Net-_U10-Pad1_ Net-_U33-Pad2_ d_and
U10  Net-_U10-Pad1_ Net-_U1-Pad5_ Net-_U10-Pad3_ d_nand
U11  Net-_U11-Pad1_ Net-_U1-Pad5_ Net-_U11-Pad3_ d_nand
U12  Net-_U12-Pad1_ Net-_U1-Pad5_ Net-_U12-Pad3_ d_nand
U13  Net-_U13-Pad1_ Net-_U1-Pad5_ Net-_U13-Pad3_ d_nand
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ PORT
U14  Net-_U11-Pad3_ Net-_U13-Pad3_ Net-_U14-Pad3_ d_and
U15  Net-_U10-Pad1_ Net-_U12-Pad3_ Net-_U15-Pad3_ d_and
X10  Net-_U10-Pad3_ Net-_U11-Pad1_ Net-_U12-Pad1_ Net-_U13-Pad1_ ? 4_and
U16  Net-_U11-Pad3_ Net-_U13-Pad3_ Net-_U16-Pad3_ d_and
X2  Net-_U10-Pad3_ Net-_U11-Pad1_ Net-_U12-Pad3_ Net-_U23-Pad2_ 3_and
X3  Net-_U10-Pad1_ Net-_U11-Pad3_ Net-_U12-Pad3_ Net-_U36-Pad2_ 3_and
U17  Net-_U12-Pad3_ Net-_U13-Pad3_ Net-_U17-Pad3_ d_and
X4  Net-_U10-Pad1_ Net-_U11-Pad3_ Net-_U12-Pad1_ Net-_U27-Pad2_ 3_and
X5  Net-_U10-Pad3_ Net-_U11-Pad1_ Net-_U12-Pad1_ Net-_U24-Pad1_ 3_and
X6  Net-_U10-Pad1_ Net-_U11-Pad1_ Net-_U12-Pad3_ Net-_U24-Pad2_ 3_and
X7  Net-_U10-Pad3_ Net-_U11-Pad3_ Net-_U12-Pad3_ Net-_U37-Pad2_ 3_and
U21  Net-_U10-Pad3_ Net-_U21-Pad2_ d_buffer
U18  Net-_U11-Pad1_ Net-_U12-Pad3_ Net-_U18-Pad3_ d_and
U19  Net-_U10-Pad3_ Net-_U11-Pad3_ Net-_U19-Pad3_ d_and
U20  Net-_U11-Pad3_ Net-_U12-Pad1_ Net-_U20-Pad3_ d_and
X8  Net-_U10-Pad3_ Net-_U12-Pad1_ Net-_U13-Pad1_ Net-_U38-Pad2_ 3_and
X9  Net-_U10-Pad3_ Net-_U11-Pad3_ Net-_U12-Pad3_ Net-_U28-Pad1_ 3_and
X11  Net-_U11-Pad1_ Net-_U12-Pad1_ Net-_U13-Pad1_ Net-_U1-Pad6_ Net-_U28-Pad2_ 4_and
U27  Net-_U17-Pad3_ Net-_U27-Pad2_ Net-_U27-Pad3_ d_nor
U26  Net-_U21-Pad2_ Net-_U18-Pad3_ Net-_U26-Pad3_ d_nor
U28  Net-_U28-Pad1_ Net-_U28-Pad2_ Net-_U28-Pad3_ d_nor
U22  Net-_U14-Pad3_ Net-_U15-Pad3_ Net-_U22-Pad3_ d_nor
U29  Net-_U22-Pad3_ Net-_U22-Pad3_ Net-_U29-Pad3_ d_nor
U35  Net-_U29-Pad3_ ? Net-_U35-Pad3_ d_nor
U23  Net-_U16-Pad3_ Net-_U23-Pad2_ Net-_U23-Pad3_ d_nor
U30  Net-_U23-Pad3_ Net-_U23-Pad3_ Net-_U30-Pad3_ d_nor
U36  Net-_U30-Pad3_ Net-_U36-Pad2_ Net-_U36-Pad3_ d_nor
U24  Net-_U24-Pad1_ Net-_U24-Pad2_ Net-_U24-Pad3_ d_nor
U31  Net-_U24-Pad3_ Net-_U24-Pad3_ Net-_U31-Pad3_ d_nor
U37  Net-_U31-Pad3_ Net-_U37-Pad2_ Net-_U37-Pad3_ d_nor
U25  Net-_U19-Pad3_ Net-_U20-Pad3_ Net-_U25-Pad3_ d_nor
U32  Net-_U25-Pad3_ Net-_U25-Pad3_ Net-_U32-Pad3_ d_nor
U38  Net-_U32-Pad3_ Net-_U38-Pad2_ Net-_U38-Pad3_ d_nor
U33  Net-_U33-Pad1_ Net-_U33-Pad2_ Net-_U1-Pad5_ d_nand
U39  Net-_U35-Pad3_ Net-_U1-Pad8_ d_inverter
U40  Net-_U36-Pad3_ Net-_U1-Pad9_ d_inverter
U34  Net-_U27-Pad3_ Net-_U1-Pad10_ d_inverter
U41  Net-_U37-Pad3_ Net-_U1-Pad11_ d_inverter
U8  Net-_U26-Pad3_ Net-_U1-Pad12_ d_inverter
U42  Net-_U38-Pad3_ Net-_U1-Pad13_ d_inverter
U7  Net-_U28-Pad3_ Net-_U1-Pad14_ d_inverter

.end
