* D:\FOSSEE\eSim\library\SubcircuitLibrary\SN7482\SN7482.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 07/13/25 08:56:10

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U3  /5 Net-_U12-Pad1_ Net-_U19-Pad1_ d_and
U4  /2 Net-_U12-Pad1_ Net-_U19-Pad2_ d_and
U5  /3 Net-_U12-Pad1_ Net-_U20-Pad1_ d_and
X1  /5 /2 /3 Net-_U20-Pad2_ 3_and
U6  /5 /2 Net-_U15-Pad1_ d_and
U7  /5 /3 Net-_U15-Pad2_ d_and
U8  /3 /2 Net-_U22-Pad2_ d_and
U9  Net-_U12-Pad1_ /10 Net-_U16-Pad1_ d_and
U10  Net-_U1-Pad2_ /10 Net-_U10-Pad3_ d_and
U11  Net-_U11-Pad1_ /10 Net-_U11-Pad3_ d_and
X2  Net-_U12-Pad1_ Net-_U1-Pad2_ Net-_U11-Pad1_ Net-_U17-Pad2_ 3_and
U12  Net-_U12-Pad1_ Net-_U1-Pad2_ Net-_U12-Pad3_ d_and
U13  Net-_U12-Pad1_ Net-_U11-Pad1_ Net-_U13-Pad3_ d_and
U14  Net-_U1-Pad2_ Net-_U11-Pad1_ Net-_U14-Pad3_ d_and
U19  Net-_U19-Pad1_ Net-_U19-Pad2_ Net-_U19-Pad3_ d_or
U20  Net-_U20-Pad1_ Net-_U20-Pad2_ Net-_U20-Pad3_ d_or
U24  Net-_U19-Pad3_ Net-_U20-Pad3_ Net-_U24-Pad3_ d_nor
U15  Net-_U15-Pad1_ Net-_U15-Pad2_ Net-_U15-Pad3_ d_or
U22  Net-_U15-Pad3_ Net-_U22-Pad2_ Net-_U12-Pad1_ d_nor
U16  Net-_U16-Pad1_ Net-_U10-Pad3_ Net-_U16-Pad3_ d_or
U17  Net-_U11-Pad3_ Net-_U17-Pad2_ Net-_U17-Pad3_ d_or
U21  Net-_U16-Pad3_ Net-_U17-Pad3_ /12 d_nor
U18  Net-_U12-Pad3_ Net-_U13-Pad3_ Net-_U18-Pad3_ d_or
U23  Net-_U18-Pad3_ Net-_U14-Pad3_ /10 d_nor
U25  Net-_U24-Pad3_ /1 d_inverter
U2  /13 Net-_U11-Pad1_ d_inverter
U1  /14 Net-_U1-Pad2_ d_inverter
U26  /1 /2 /3 ? /5 ? ? ? ? /10 ? /12 /13 /14 PORT

.end
