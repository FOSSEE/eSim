.title KiCad schematic
U26 Net-_U26-Pad1_ Net-_U24-Pad2_ Net-_U1-Pad11_ d_and
U1 Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U16-Pad2_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ GND Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ GND PORT
X11 Net-_U33-Pad1_ Net-_U29-Pad3_ Net-_U12-Pad2_ Net-_U31-Pad1_ 3_and
U25 Net-_U1-Pad2_ Net-_U25-Pad2_ Net-_U23-Pad1_ d_nand
U34 Net-_U1-Pad7_ Net-_U25-Pad2_ Net-_U33-Pad1_ d_nand
U30 Net-_U1-Pad1_ Net-_U25-Pad2_ Net-_U12-Pad1_ d_nand
U21 Net-_U1-Pad6_ Net-_U19-Pad1_ d_inverter
U41 Net-_U40-Pad3_ Net-_U41-Pad2_ d_inverter
U39 Net-_U38-Pad3_ Net-_U39-Pad2_ d_inverter
U40 Net-_U29-Pad3_ Net-_U19-Pad3_ Net-_U40-Pad3_ d_and
U35 Net-_U29-Pad3_ Net-_U19-Pad3_ Net-_U35-Pad3_ d_and
U31 Net-_U31-Pad1_ Net-_U31-Pad2_ d_inverter
X12 Net-_U15-Pad1_ Net-_U12-Pad1_ Net-_U12-Pad2_ Net-_U32-Pad1_ 3_and
U36 Net-_U35-Pad3_ Net-_U36-Pad2_ d_inverter
U32 Net-_U32-Pad1_ Net-_U32-Pad2_ d_inverter
X15 Net-_U41-Pad2_ Net-_U39-Pad2_ Net-_U37-Pad2_ Net-_U1-Pad13_ 3_and
U37 Net-_U37-Pad1_ Net-_U37-Pad2_ d_inverter
X13 Net-_U36-Pad2_ Net-_U32-Pad2_ Net-_U31-Pad2_ Net-_U1-Pad12_ 3_and
U38 Net-_U33-Pad1_ Net-_U12-Pad2_ Net-_U38-Pad3_ d_and
X14 Net-_U15-Pad1_ Net-_U12-Pad1_ Net-_U23-Pad1_ Net-_U19-Pad1_ Net-_U37-Pad1_ 4_and
U23 Net-_U23-Pad1_ Net-_U19-Pad2_ Net-_U12-Pad2_ d_nand
U19 Net-_U19-Pad1_ Net-_U19-Pad2_ Net-_U19-Pad3_ d_nand
U24 Net-_U24-Pad1_ Net-_U24-Pad2_ d_inverter
U28 Net-_U27-Pad3_ Net-_U26-Pad1_ d_inverter
X9 Net-_U15-Pad1_ Net-_U12-Pad1_ Net-_U23-Pad1_ Net-_U22-Pad1_ 3_and
U22 Net-_U22-Pad1_ Net-_U22-Pad2_ d_inverter
U20 Net-_U20-Pad1_ Net-_U20-Pad2_ d_inverter
X7 Net-_U33-Pad1_ Net-_U12-Pad1_ Net-_U12-Pad2_ Net-_U20-Pad1_ 3_and
X10 Net-_U33-Pad1_ Net-_U29-Pad3_ Net-_U23-Pad1_ Net-_U24-Pad1_ 3_and
U27 Net-_U12-Pad2_ Net-_U19-Pad3_ Net-_U27-Pad3_ d_and
X8 Net-_U22-Pad2_ Net-_U20-Pad2_ Net-_U18-Pad2_ Net-_U1-Pad10_ 3_and
U29 Net-_U12-Pad1_ Net-_U19-Pad2_ Net-_U29-Pad3_ d_nand
U33 Net-_U33-Pad1_ Net-_U19-Pad2_ Net-_U15-Pad1_ d_nand
U42 Net-_U1-Pad5_ Net-_U11-Pad1_ d_inverter
U43 Net-_U1-Pad3_ Net-_U43-Pad2_ d_inverter
U5 Net-_U43-Pad2_ Net-_U25-Pad2_ d_inverter
X5 Net-_U25-Pad2_ Net-_U19-Pad1_ Net-_U23-Pad1_ Net-_U12-Pad1_ Net-_U33-Pad1_ Net-_U11-Pad2_ 5_and
U12 Net-_U12-Pad1_ Net-_U12-Pad2_ Net-_U12-Pad3_ d_and
U13 Net-_U12-Pad3_ Net-_U13-Pad2_ d_inverter
U15 Net-_U15-Pad1_ Net-_U14-Pad1_ d_inverter
U14 Net-_U14-Pad1_ Net-_U13-Pad2_ Net-_U1-Pad9_ d_and
U9 Net-_U15-Pad1_ Net-_U29-Pad3_ Net-_U10-Pad1_ d_and
U10 Net-_U10-Pad1_ Net-_U10-Pad2_ d_inverter
U18 Net-_U18-Pad1_ Net-_U18-Pad2_ d_inverter
X6 Net-_U15-Pad1_ Net-_U29-Pad3_ Net-_U12-Pad2_ Net-_U18-Pad1_ 3_and
U7 Net-_U29-Pad3_ Net-_U23-Pad1_ Net-_U7-Pad3_ d_and
X3 Net-_U15-Pad1_ Net-_U23-Pad1_ Net-_U19-Pad1_ Net-_U6-Pad1_ 3_and
U8 Net-_U7-Pad3_ Net-_U8-Pad2_ d_inverter
U6 Net-_U6-Pad1_ Net-_U6-Pad2_ d_inverter
X4 Net-_U10-Pad2_ Net-_U8-Pad2_ Net-_U6-Pad2_ Net-_U1-Pad15_ 3_and
U3 Net-_U3-Pad1_ Net-_U2-Pad2_ Net-_U1-Pad14_ d_and
U2 Net-_U2-Pad1_ Net-_U2-Pad2_ d_inverter
U4 Net-_U4-Pad1_ Net-_U3-Pad1_ d_inverter
X2 Net-_U15-Pad1_ Net-_U29-Pad3_ Net-_U12-Pad2_ Net-_U4-Pad1_ 3_and
X1 Net-_U12-Pad1_ Net-_U23-Pad1_ Net-_U19-Pad1_ Net-_U25-Pad2_ Net-_U2-Pad1_ 4_and
U17 Net-_U16-Pad2_ Net-_U17-Pad2_ d_inverter
U16 Net-_U11-Pad3_ Net-_U16-Pad2_ d_inverter
U44 Net-_U17-Pad2_ Net-_U19-Pad2_ d_inverter
U11 Net-_U11-Pad1_ Net-_U11-Pad2_ Net-_U11-Pad3_ d_and
.end
