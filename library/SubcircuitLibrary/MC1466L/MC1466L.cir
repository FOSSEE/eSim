.title KiCad schematic
D2 Net-_D1-Pad2_ Net-_D2-Pad2_ eSim_Diode
D3 Net-_D2-Pad2_ Net-_D3-Pad2_ eSim_Diode
U1 Net-_Q5-Pad1_ Net-_Q5-Pad3_ Net-_R8-Pad1_ Net-_D6-Pad2_ Net-_Q15-Pad1_ Net-_D13-Pad2_ Net-_D7-Pad2_ Net-_R9-Pad1_ Net-_D3-Pad2_ Net-_Q12-Pad2_ Net-_Q10-Pad2_ Net-_D4-Pad1_ Net-_Q1-Pad1_ Net-_Q2-Pad3_ PORT
U2 Net-_D7-Pad2_ Net-_D3-Pad2_ zener
R4 Net-_D7-Pad2_ Net-_Q1-Pad3_ 15k
Q4 Net-_Q2-Pad3_ Net-_Q4-Pad2_ Net-_Q1-Pad3_ eSim_NPN
Q1 Net-_Q1-Pad1_ Net-_D1-Pad1_ Net-_Q1-Pad3_ eSim_NPN
D1 Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
Q2 Net-_Q2-Pad1_ Net-_Q1-Pad1_ Net-_Q2-Pad3_ eSim_PNP
R1 Net-_Q1-Pad1_ Net-_Q2-Pad3_ 3k
R5 Net-_Q2-Pad1_ Net-_D4-Pad1_ 7.5k
R2 Net-_D1-Pad1_ Net-_D4-Pad1_ 16k
U3 Net-_Q4-Pad2_ Net-_D6-Pad2_ zener
D6 Net-_D5-Pad2_ Net-_D6-Pad2_ eSim_Diode
D4 Net-_D4-Pad1_ Net-_D4-Pad2_ eSim_Diode
D5 Net-_D4-Pad2_ Net-_D5-Pad2_ eSim_Diode
R8 Net-_R8-Pad1_ Net-_Q6-Pad3_ 550
Q6 Net-_Q5-Pad3_ Net-_Q5-Pad1_ Net-_Q6-Pad3_ eSim_NPN
R6 Net-_Q11-Pad2_ Net-_Q4-Pad2_ 16k
Q7 Net-_D13-Pad1_ Net-_D8-Pad1_ Net-_Q7-Pad3_ eSim_NPN
R11 Net-_Q8-Pad1_ Net-_Q7-Pad3_ 30
Q9 Net-_Q9-Pad1_ Net-_D8-Pad2_ Net-_Q8-Pad1_ eSim_NPN
R9 Net-_R9-Pad1_ Net-_D8-Pad1_ 500
D9 Net-_D8-Pad2_ Net-_D8-Pad1_ eSim_Diode
R7 Net-_D7-Pad1_ Net-_Q11-Pad2_ 2.2k
D7 Net-_D7-Pad1_ Net-_D7-Pad2_ eSim_Diode
Q8 Net-_Q8-Pad1_ Net-_Q11-Pad2_ Net-_Q8-Pad3_ eSim_NPN
R12 Net-_D7-Pad2_ Net-_Q8-Pad3_ 1.1k
D8 Net-_D8-Pad1_ Net-_D8-Pad2_ eSim_Diode
Q3 Net-_Q2-Pad3_ Net-_Q2-Pad1_ Net-_D4-Pad1_ eSim_NPN
R3 Net-_Q2-Pad3_ Net-_D4-Pad1_ 3.9k
Q5 Net-_Q5-Pad1_ Net-_Q4-Pad2_ Net-_Q5-Pad3_ eSim_PNP
R10 Net-_D13-Pad1_ Net-_D4-Pad1_ 19.6k
R13 Net-_Q9-Pad1_ Net-_D4-Pad1_ 8k
R15 Net-_Q10-Pad1_ Net-_D4-Pad1_ 4.3k
R17 Net-_D10-Pad1_ Net-_D4-Pad1_ 15k
R19 Net-_D3-Pad2_ Net-_D12-Pad2_ 7.5k
Q15 Net-_Q15-Pad1_ Net-_D13-Pad2_ Net-_D3-Pad2_ eSim_NPN
D13 Net-_D13-Pad1_ Net-_D13-Pad2_ eSim_Diode
D14 Net-_D12-Pad2_ Net-_D13-Pad2_ eSim_Diode
R21 Net-_Q15-Pad1_ Net-_Q14-Pad3_ 1.5k
Q14 Net-_Q13-Pad3_ Net-_Q13-Pad1_ Net-_Q14-Pad3_ eSim_NPN
D11 Net-_D10-Pad2_ Net-_D11-Pad2_ eSim_Diode
D10 Net-_D10-Pad1_ Net-_D10-Pad2_ eSim_Diode
D12 Net-_D11-Pad2_ Net-_D12-Pad2_ eSim_Diode
R20 Net-_Q13-Pad3_ Net-_D4-Pad1_ 750
Q13 Net-_Q13-Pad1_ Net-_D6-Pad2_ Net-_Q13-Pad3_ eSim_PNP
R14 Net-_D3-Pad2_ Net-_D8-Pad2_ 500
Q10 Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
Q12 Net-_D10-Pad1_ Net-_Q12-Pad2_ Net-_Q12-Pad3_ eSim_NPN
Q11 Net-_Q10-Pad3_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_NPN
R18 Net-_Q10-Pad3_ Net-_Q12-Pad3_ 30
R16 Net-_D7-Pad2_ Net-_Q11-Pad3_ 1.8k
.end
