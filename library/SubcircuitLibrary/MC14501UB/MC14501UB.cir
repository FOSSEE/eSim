* C:\FOSSEE\eSim\library\SubcircuitLibrary\MC14501UB\MC14501UB.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/26/25 10:03:18

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
M9  Net-_M1-Pad1_ Net-_M16-Pad2_ Net-_M10-Pad3_ Net-_M1-Pad1_ mosfet_p
M10  Net-_M1-Pad1_ Net-_M10-Pad2_ Net-_M10-Pad3_ Net-_M1-Pad1_ mosfet_p
M11  Net-_M1-Pad1_ Net-_M11-Pad2_ Net-_M10-Pad3_ Net-_M1-Pad1_ mosfet_p
M12  Net-_M1-Pad1_ Net-_M12-Pad2_ Net-_M10-Pad3_ Net-_M1-Pad1_ mosfet_p
M13  Net-_M10-Pad3_ Net-_M12-Pad2_ Net-_M13-Pad3_ Net-_M13-Pad4_ mosfet_n
M14  Net-_M13-Pad3_ Net-_M11-Pad2_ Net-_M14-Pad3_ Net-_M13-Pad4_ mosfet_n
M15  Net-_M14-Pad3_ Net-_M10-Pad2_ Net-_M15-Pad3_ Net-_M13-Pad4_ mosfet_n
M16  Net-_M15-Pad3_ Net-_M16-Pad2_ Net-_M13-Pad4_ Net-_M13-Pad4_ mosfet_n
M18  Net-_M1-Pad1_ Net-_M17-Pad2_ Net-_M18-Pad3_ Net-_M1-Pad1_ mosfet_p
M19  Net-_M18-Pad3_ Net-_M19-Pad2_ Net-_M17-Pad1_ Net-_M1-Pad1_ mosfet_p
M17  Net-_M17-Pad1_ Net-_M17-Pad2_ Net-_M13-Pad4_ Net-_M13-Pad4_ mosfet_n
M20  Net-_M17-Pad1_ Net-_M19-Pad2_ Net-_M13-Pad4_ Net-_M13-Pad4_ mosfet_n
M22  Net-_M1-Pad1_ Net-_M17-Pad1_ Net-_M21-Pad1_ Net-_M1-Pad1_ mosfet_p
M21  Net-_M21-Pad1_ Net-_M17-Pad1_ Net-_M13-Pad4_ Net-_M13-Pad4_ mosfet_n
M1  Net-_M1-Pad1_ Net-_M1-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad1_ mosfet_p
M2  Net-_M1-Pad1_ Net-_M2-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad1_ mosfet_p
M3  Net-_M1-Pad1_ Net-_M3-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad1_ mosfet_p
M4  Net-_M1-Pad1_ Net-_M4-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad1_ mosfet_p
M5  Net-_M1-Pad3_ Net-_M4-Pad2_ Net-_M5-Pad3_ Net-_M13-Pad4_ mosfet_n
M6  Net-_M5-Pad3_ Net-_M3-Pad2_ Net-_M6-Pad3_ Net-_M13-Pad4_ mosfet_n
M7  Net-_M6-Pad3_ Net-_M2-Pad2_ Net-_M7-Pad3_ Net-_M13-Pad4_ mosfet_n
M8  Net-_M7-Pad3_ Net-_M1-Pad2_ Net-_M13-Pad4_ Net-_M13-Pad4_ mosfet_n
U1  Net-_M1-Pad2_ Net-_M3-Pad2_ Net-_M2-Pad2_ Net-_M4-Pad2_ Net-_M16-Pad2_ Net-_M11-Pad2_ Net-_M10-Pad2_ Net-_M13-Pad4_ Net-_M12-Pad2_ Net-_M10-Pad3_ Net-_M17-Pad2_ Net-_M19-Pad2_ Net-_M1-Pad3_ Net-_M17-Pad1_ Net-_M21-Pad1_ Net-_M1-Pad1_ PORT

.end
