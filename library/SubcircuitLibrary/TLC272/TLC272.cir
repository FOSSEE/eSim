* C:\Users\HP\OneDrive\Documents\FOSSEE\eSim\library\SubcircuitLibrary\TLC272\TLC272.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/11/25 15:51:19

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
M2  Net-_M10-Pad1_ Net-_M2-Pad2_ Net-_D2-Pad2_ Net-_M1-Pad4_ mosfet_p
M10  Net-_M10-Pad1_ Net-_M10-Pad2_ Net-_D4-Pad2_ Net-_M1-Pad4_ mosfet_p
M4  Net-_D2-Pad2_ Net-_D2-Pad2_ Net-_M4-Pad3_ Net-_D1-Pad1_ mosfet_n
M7  Net-_D4-Pad2_ Net-_D2-Pad2_ Net-_M7-Pad3_ Net-_D1-Pad1_ mosfet_n
M8  Net-_M1-Pad4_ Net-_M14-Pad2_ Net-_M10-Pad1_ Net-_M1-Pad4_ mosfet_p
R2  Net-_M4-Pad3_ Net-_D1-Pad1_ 3k
R4  Net-_M7-Pad3_ Net-_D1-Pad1_ 3k
D2  Net-_D1-Pad1_ Net-_D2-Pad2_ eSim_Diode
M14  Net-_M1-Pad4_ Net-_M14-Pad2_ Net-_M13-Pad1_ Net-_M1-Pad4_ mosfet_p
M13  Net-_M13-Pad1_ Net-_D4-Pad2_ Net-_D1-Pad1_ Net-_D1-Pad1_ mosfet_n
R6  Net-_C2-Pad1_ Net-_D4-Pad2_ 10k
C2  Net-_C2-Pad1_ Net-_C2-Pad2_ 30p
D4  Net-_D1-Pad1_ Net-_D4-Pad2_ eSim_Diode
M18  Net-_C2-Pad2_ Net-_D4-Pad2_ Net-_D1-Pad1_ Net-_D1-Pad1_ mosfet_n
M17  Net-_M17-Pad1_ Net-_M13-Pad1_ Net-_C2-Pad2_ Net-_D1-Pad1_ mosfet_n
R8  Net-_M1-Pad4_ Net-_M17-Pad1_ 39k
M22  Net-_M1-Pad4_ Net-_M14-Pad2_ Net-_M14-Pad2_ Net-_M1-Pad4_ mosfet_p
M26  Net-_M1-Pad4_ Net-_M14-Pad2_ Net-_M21-Pad2_ Net-_M1-Pad4_ mosfet_p
M21  Net-_M14-Pad2_ Net-_M21-Pad2_ Net-_M21-Pad3_ Net-_D1-Pad1_ mosfet_n
M25  Net-_M21-Pad2_ Net-_M21-Pad2_ Net-_D1-Pad1_ Net-_D1-Pad1_ mosfet_n
R10  Net-_M21-Pad3_ Net-_D1-Pad1_ 100k
M1  Net-_M1-Pad1_ Net-_M1-Pad2_ Net-_D1-Pad2_ Net-_M1-Pad4_ mosfet_p
M9  Net-_M1-Pad1_ Net-_M9-Pad2_ Net-_D3-Pad2_ Net-_M1-Pad4_ mosfet_p
M3  Net-_D1-Pad2_ Net-_D1-Pad2_ Net-_M3-Pad3_ Net-_D1-Pad1_ mosfet_n
M5  Net-_D3-Pad2_ Net-_D1-Pad2_ Net-_M5-Pad3_ Net-_D1-Pad1_ mosfet_n
M6  Net-_M1-Pad4_ Net-_M12-Pad2_ Net-_M1-Pad1_ Net-_M1-Pad4_ mosfet_p
R1  Net-_M3-Pad3_ Net-_D1-Pad1_ 3k
R3  Net-_M5-Pad3_ Net-_D1-Pad1_ 3k
D1  Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
M12  Net-_M1-Pad4_ Net-_M12-Pad2_ Net-_M11-Pad1_ Net-_M1-Pad4_ mosfet_p
M11  Net-_M11-Pad1_ Net-_D3-Pad2_ Net-_D1-Pad1_ Net-_D1-Pad1_ mosfet_n
R5  Net-_C1-Pad1_ Net-_D3-Pad2_ 10k
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 30p
D3  Net-_D1-Pad1_ Net-_D3-Pad2_ eSim_Diode
M16  Net-_C1-Pad2_ Net-_D3-Pad2_ Net-_D1-Pad1_ Net-_D1-Pad1_ mosfet_n
M15  Net-_M15-Pad1_ Net-_M11-Pad1_ Net-_C1-Pad2_ Net-_D1-Pad1_ mosfet_n
R7  Net-_M1-Pad4_ Net-_M15-Pad1_ 39k
M20  Net-_M1-Pad4_ Net-_M12-Pad2_ Net-_M12-Pad2_ Net-_M1-Pad4_ mosfet_p
M24  Net-_M1-Pad4_ Net-_M12-Pad2_ Net-_M19-Pad2_ Net-_M1-Pad4_ mosfet_p
M19  Net-_M12-Pad2_ Net-_M19-Pad2_ Net-_M19-Pad3_ Net-_D1-Pad1_ mosfet_n
M23  Net-_M19-Pad2_ Net-_M19-Pad2_ Net-_D1-Pad1_ Net-_D1-Pad1_ mosfet_n
R9  Net-_M19-Pad3_ Net-_D1-Pad1_ 100k
U1  Net-_M1-Pad4_ Net-_M2-Pad2_ Net-_M10-Pad2_ Net-_D1-Pad1_ Net-_M1-Pad2_ Net-_M9-Pad2_ Net-_C2-Pad2_ Net-_C1-Pad2_ PORT

.end
