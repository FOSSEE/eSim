.title KiCad schematic
U1 Net-_J6-Pad1_ Net-_J4-Pad2_ Net-_J1-Pad2_ Net-_C1-Pad2_ Net-_J5-Pad1_ Net-_D5-Pad1_ Net-_D5-Pad1_ unconnected-_U1-Pad8_ PORT
D6 Net-_C2-Pad1_ Net-_C2-Pad1_ diode
Q17 Net-_C2-Pad1_ Net-_C2-Pad1_ Net-_D5-Pad1_ eSim_NPN
R8 Net-_C2-Pad1_ Net-_D5-Pad1_ 25
Q13 Net-_D5-Pad1_ Net-_D3-Pad1_ Net-_C2-Pad1_ eSim_NPN
J10 Net-_C2-Pad1_ Net-_D3-Pad2_ Net-_J10-Pad3_ eSim_PJF
Q10 Net-_D2-Pad1_ Net-_D2-Pad1_ Net-_D5-Pad1_ eSim_PNP
J8 Net-_D2-Pad1_ Net-_D2-Pad1_ Net-_D1-Pad1_ eSim_PJF
Q8 Net-_C1-Pad2_ Net-_C2-Pad1_ Net-_C2-Pad2_ eSim_PNP
Q11 Net-_D5-Pad1_ Net-_C2-Pad1_ Net-_D3-Pad1_ eSim_PNP
D3 Net-_D3-Pad1_ Net-_D3-Pad2_ diode
D1 Net-_D1-Pad1_ Net-_C1-Pad2_ diode
D2 Net-_D2-Pad1_ Net-_C1-Pad2_ diode
Q3 Net-_D5-Pad1_ Net-_Q2-Pad3_ Net-_Q3-Pad3_ eSim_NPN
Q2 Net-_D5-Pad1_ Net-_C1-Pad1_ Net-_Q2-Pad3_ eSim_NPN
R4 Net-_Q1-Pad2_ Net-_Q6-Pad3_ 30
R3 Net-_Q3-Pad3_ Net-_Q1-Pad2_ 30
Q6 Net-_C2-Pad1_ Net-_Q6-Pad2_ Net-_Q6-Pad3_ eSim_NPN
Q9 Net-_D5-Pad1_ Net-_C2-Pad2_ Net-_Q6-Pad2_ eSim_NPN
J5 Net-_J5-Pad1_ Net-_D5-Pad1_ Net-_C2-Pad2_ eSim_PJF
J6 Net-_J6-Pad1_ Net-_D5-Pad1_ Net-_C1-Pad1_ eSim_PJF
J7 Net-_J7-Pad1_ Net-_D2-Pad1_ Net-_C2-Pad1_ eSim_PJF
Q5 Net-_C1-Pad1_ Net-_D2-Pad1_ Net-_D5-Pad1_ eSim_PNP
C2 Net-_C2-Pad1_ Net-_C2-Pad2_ 10p
Q7 Net-_J7-Pad1_ Net-_D2-Pad1_ Net-_D5-Pad1_ eSim_PNP
C1 Net-_C1-Pad1_ Net-_C1-Pad2_ 10p
J1 Net-_C1-Pad1_ Net-_J1-Pad2_ Net-_C2-Pad2_ eSim_PJF
J2 Net-_C2-Pad2_ Net-_C2-Pad2_ Net-_C1-Pad2_ eSim_PJF
J3 Net-_C1-Pad1_ Net-_C1-Pad1_ Net-_C1-Pad2_ eSim_PJF
J4 Net-_C1-Pad1_ Net-_J4-Pad2_ Net-_C1-Pad1_ eSim_PJF
Q1 Net-_C1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
R1 Net-_C1-Pad2_ Net-_Q1-Pad3_ 1k
Q4 Net-_Q1-Pad2_ Net-_D1-Pad1_ Net-_C1-Pad2_ eSim_NPN
R5 Net-_C1-Pad2_ Net-_Q6-Pad2_ 5k
R2 Net-_C1-Pad2_ Net-_Q2-Pad3_ 5k
R7 Net-_C1-Pad2_ Net-_Q16-Pad3_ 50
Q16 Net-_C2-Pad1_ Net-_Q15-Pad3_ Net-_Q16-Pad3_ eSim_NPN
D4 Net-_D4-Pad1_ Net-_C1-Pad2_ diode
Q12 Net-_D3-Pad2_ Net-_D2-Pad1_ Net-_C1-Pad2_ eSim_PNP
Q15 Net-_D5-Pad1_ Net-_J10-Pad3_ Net-_Q15-Pad3_ eSim_NPN
D5 Net-_D5-Pad1_ Net-_D3-Pad2_ diode
R6 Net-_C1-Pad2_ Net-_Q15-Pad3_ 3k
Q14 Net-_J10-Pad3_ Net-_C1-Pad2_ Net-_C1-Pad2_ eSim_NPN
J9 Net-_D3-Pad2_ Net-_D3-Pad2_ Net-_D4-Pad1_ eSim_PJF
.end
