* C:\FOSSEE\eSim\library\SubcircuitLibrary\LM140k_SUB\LM140k_SUB.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 08/31/24 15:45:18

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
R1  Net-_C3-Pad1_ Net-_Q1-Pad2_ 80K
Q1  Net-_C3-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
R2  Net-_Q1-Pad3_ Net-_Q3-Pad2_ 7K
U1  Net-_C4-Pad2_ Net-_Q1-Pad2_ zener
R3  Net-_Q3-Pad2_ Net-_Q2-Pad2_ 4.97k
R4  Net-_Q2-Pad2_ Net-_C4-Pad2_ 830
Q4  Net-_Q3-Pad1_ Net-_Q3-Pad1_ Net-_C3-Pad1_ eSim_PNP
Q8  Net-_Q12-Pad1_ Net-_Q3-Pad1_ Net-_C3-Pad1_ eSim_PNP
Q5  Net-_Q3-Pad1_ Net-_Q1-Pad3_ Net-_Q5-Pad3_ eSim_NPN
Q3  Net-_Q3-Pad1_ Net-_Q3-Pad2_ Net-_Q3-Pad3_ eSim_NPN
Q6  Net-_Q5-Pad3_ Net-_Q13-Pad2_ Net-_Q6-Pad3_ eSim_NPN
R5  Net-_Q3-Pad3_ Net-_Q6-Pad3_ 500
R7  Net-_Q6-Pad3_ Net-_Q7-Pad2_ 1.9k
Q7  Net-_Q6-Pad3_ Net-_Q7-Pad2_ Net-_C1-Pad2_ eSim_NPN
R9  Net-_Q10-Pad3_ Net-_C4-Pad2_ 12.1k
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 4pF
R6  Net-_C1-Pad2_ Net-_C4-Pad2_ 1.2k
Q2  Net-_Q12-Pad1_ Net-_Q2-Pad2_ Net-_C4-Pad2_ eSim_NPN
R8  Net-_Q7-Pad2_ Net-_C1-Pad1_ 26
Q9  Net-_C1-Pad1_ Net-_C1-Pad2_ Net-_C4-Pad2_ eSim_NPN
Q10  Net-_Q10-Pad1_ Net-_C1-Pad1_ Net-_Q10-Pad3_ eSim_NPN
U2  Net-_Q12-Pad2_ Net-_R13-Pad2_ zener
R13  Net-_C3-Pad1_ Net-_R13-Pad2_ 16k
Q13  Net-_Q13-Pad1_ Net-_Q13-Pad2_ Net-_Q10-Pad1_ eSim_NPN
R12  Net-_Q11-Pad3_ Net-_C4-Pad2_ 1k
Q11  Net-_C2-Pad2_ Net-_Q10-Pad3_ Net-_Q11-Pad3_ eSim_NPN
R11  Net-_Q10-Pad1_ Net-_C2-Pad2_ 16.5k
Q12  Net-_Q12-Pad1_ Net-_Q12-Pad2_ Net-_Q12-Pad3_ eSim_NPN
R10  Net-_Q12-Pad3_ Net-_C4-Pad1_ 100
R15  Net-_Q19-Pad3_ Net-_Q12-Pad2_ 380
Q17  Net-_C3-Pad1_ Net-_Q12-Pad1_ Net-_Q13-Pad1_ eSim_NPN
Q19  Net-_C3-Pad1_ Net-_Q13-Pad1_ Net-_Q19-Pad3_ eSim_NPN
R18  Net-_Q13-Pad1_ Net-_Q12-Pad2_ 1.62k
R19  Net-_C4-Pad1_ Net-_Q19-Pad3_ 0.25
R20  Net-_Q13-Pad2_ Net-_C4-Pad1_ 1.39k
R16  Net-_Q12-Pad1_ Net-_Q18-Pad3_ 850
R17  Net-_Q18-Pad3_ Net-_C2-Pad1_ 4k
Q16  Net-_C2-Pad1_ Net-_Q14-Pad3_ Net-_C4-Pad2_ eSim_NPN
C2  Net-_C2-Pad1_ Net-_C2-Pad2_ 20pF
Q14  Net-_C2-Pad1_ Net-_C2-Pad2_ Net-_Q14-Pad3_ eSim_NPN
R14  Net-_Q15-Pad3_ Net-_C4-Pad2_ 4k
Q15  Net-_Q14-Pad3_ Net-_Q14-Pad3_ Net-_Q15-Pad3_ eSim_NPN
Q18  Net-_C4-Pad2_ Net-_C2-Pad1_ Net-_Q18-Pad3_ eSim_PNP
R21  Net-_C4-Pad2_ Net-_Q13-Pad2_ 2.67k
C3  Net-_C3-Pad1_ GND 0.01uF
C4  Net-_C4-Pad1_ Net-_C4-Pad2_ 0.01uF
U3  Net-_C3-Pad1_ Net-_C4-Pad1_ Net-_C4-Pad2_ PORT

.end
