* C:\FOSSEE\eSim\library\SubcircuitLibrary\LM341_sub\LM341_sub.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 13/06/2024 6:43:58 PM

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
R1  Net-_Q1-Pad2_ Net-_Q1-Pad1_ 80k
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
R2  Net-_Q3-Pad2_ Net-_Q1-Pad3_ 7k
R3  Net-_Q2-Pad2_ Net-_Q3-Pad2_ 4.97k
R4  Net-_Q16-Pad3_ Net-_Q2-Pad2_ 830
R6  Net-_Q16-Pad3_ Net-_C1-Pad1_ 1.2k
R9  Net-_Q16-Pad3_ Net-_Q10-Pad3_ 12.1k
R12  Net-_Q16-Pad3_ Net-_Q11-Pad3_ 1k
R15  Net-_Q16-Pad3_ Net-_Q15-Pad3_ 4k
Q2  Net-_Q12-Pad1_ Net-_Q2-Pad2_ Net-_Q16-Pad3_ eSim_NPN
Q9  Net-_C1-Pad2_ Net-_C1-Pad1_ Net-_Q16-Pad3_ eSim_NPN
Q10  Net-_Q10-Pad1_ Net-_C1-Pad2_ Net-_Q10-Pad3_ eSim_NPN
Q11  Net-_C2-Pad1_ Net-_Q10-Pad3_ Net-_Q11-Pad3_ eSim_NPN
Q15  Net-_Q14-Pad3_ Net-_Q14-Pad3_ Net-_Q15-Pad3_ eSim_NPN
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 4pF
Q7  Net-_Q6-Pad3_ Net-_Q7-Pad2_ Net-_C1-Pad1_ eSim_NPN
Q14  Net-_C2-Pad2_ Net-_C2-Pad1_ Net-_Q14-Pad3_ eSim_NPN
Q16  Net-_C2-Pad2_ Net-_Q14-Pad3_ Net-_Q16-Pad3_ eSim_NPN
C2  Net-_C2-Pad1_ Net-_C2-Pad2_ 20pF
R8  Net-_C1-Pad2_ Net-_Q7-Pad2_ 26
R7  Net-_Q7-Pad2_ Net-_Q6-Pad3_ 1.9k
R11  Net-_C2-Pad1_ Net-_Q10-Pad1_ 16.5k
Q18  Net-_Q16-Pad3_ Net-_C2-Pad2_ Net-_Q18-Pad3_ eSim_PNP
R17  Net-_C2-Pad2_ Net-_Q18-Pad3_ 4k
R16  Net-_Q18-Pad3_ Net-_Q12-Pad1_ 850
R21  Net-_Q16-Pad3_ Net-_Q13-Pad2_ 2.67k
Q13  Net-_Q13-Pad1_ Net-_Q13-Pad2_ Net-_Q10-Pad1_ eSim_NPN
Q3  Net-_Q3-Pad1_ Net-_Q3-Pad2_ Net-_Q3-Pad3_ eSim_NPN
Q6  Net-_Q5-Pad3_ Net-_Q13-Pad2_ Net-_Q6-Pad3_ eSim_NPN
R5  Net-_Q6-Pad3_ Net-_Q3-Pad3_ 500
Q5  Net-_Q3-Pad1_ Net-_Q1-Pad3_ Net-_Q5-Pad3_ eSim_NPN
R20  Net-_Q13-Pad2_ Net-_R10-Pad1_ 1.43k
R19  Net-_R10-Pad1_ Net-_Q19-Pad3_ 0.25
R10  Net-_R10-Pad1_ Net-_Q12-Pad3_ 100
R18  Net-_Q12-Pad2_ Net-_Q13-Pad1_ 1.62k
Q12  Net-_Q12-Pad1_ Net-_Q12-Pad2_ Net-_Q12-Pad3_ eSim_NPN
R14  Net-_Q12-Pad2_ Net-_Q19-Pad3_ 380
U3  Net-_Q12-Pad2_ Net-_R13-Pad1_ zener
R13  Net-_R13-Pad1_ Net-_R13-Pad2_ 16k
Q19  Net-_Q1-Pad1_ Net-_Q13-Pad1_ Net-_Q19-Pad3_ eSim_NPN
Q17  Net-_Q1-Pad1_ Net-_Q12-Pad1_ Net-_Q13-Pad1_ eSim_NPN
Q4  Net-_Q3-Pad1_ Net-_Q3-Pad1_ Net-_Q1-Pad1_ eSim_PNP
Q8  Net-_Q12-Pad1_ Net-_Q3-Pad1_ Net-_Q1-Pad1_ eSim_PNP
U1  Net-_Q16-Pad3_ Net-_Q1-Pad2_ zener
U2  Net-_R13-Pad2_ Net-_Q1-Pad1_ zener
U4  Net-_Q1-Pad1_ Net-_Q16-Pad3_ Net-_R10-Pad1_ PORT

.end
