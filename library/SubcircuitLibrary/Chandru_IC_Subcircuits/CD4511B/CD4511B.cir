* C:\Users\chand\esim\FOSSEE\eSim\library\SubcircuitLibrary\CD4511B\CD4511B.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/26/25 22:17:26

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
M3  Net-_M3-Pad1_ Net-_M3-Pad2_ Net-_M3-Pad3_ GND mosfet_n
M7  Net-_M3-Pad3_ Net-_M7-Pad2_ Net-_M3-Pad1_ VCC mosfet_p
U26  Net-_M3-Pad3_ Net-_U26-Pad2_ adc_bridge_1
U22  Net-_U11-Pad2_ Net-_M7-Pad2_ dac_bridge_1
U14  Net-_U14-Pad1_ Net-_M3-Pad1_ dac_bridge_1
U9  Net-_U4-Pad2_ Net-_U14-Pad1_ d_inverter
U4  Net-_U106-Pad7_ Net-_U4-Pad2_ adc_bridge_1
U30  Net-_U26-Pad2_ Net-_U30-Pad2_ d_inverter
U33  Net-_U30-Pad2_ Net-_U33-Pad2_ d_inverter
U18  Net-_U11-Pad1_ Net-_M3-Pad2_ dac_bridge_1
M1  Net-_M1-Pad1_ Net-_M1-Pad2_ Net-_M1-Pad3_ GND mosfet_n
M5  Net-_M1-Pad3_ Net-_M5-Pad2_ Net-_M1-Pad1_ VCC mosfet_p
U24  Net-_M1-Pad3_ Net-_U24-Pad2_ adc_bridge_1
U19  Net-_U11-Pad2_ Net-_M5-Pad2_ dac_bridge_1
U12  Net-_U12-Pad1_ Net-_M1-Pad1_ dac_bridge_1
U7  Net-_U2-Pad2_ Net-_U12-Pad1_ d_inverter
U2  Net-_U106-Pad1_ Net-_U2-Pad2_ adc_bridge_1
U28  Net-_U24-Pad2_ Net-_U28-Pad2_ d_inverter
U32  Net-_U28-Pad2_ Net-_U32-Pad2_ d_inverter
U16  Net-_U11-Pad1_ Net-_M1-Pad2_ dac_bridge_1
M4  Net-_M4-Pad1_ Net-_M4-Pad2_ Net-_M4-Pad3_ GND mosfet_n
M8  Net-_M4-Pad3_ Net-_M8-Pad2_ Net-_M4-Pad1_ VCC mosfet_p
U27  Net-_M4-Pad3_ Net-_U27-Pad2_ adc_bridge_1
U23  Net-_U11-Pad2_ Net-_M8-Pad2_ dac_bridge_1
U15  Net-_U10-Pad2_ Net-_M4-Pad1_ dac_bridge_1
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ d_inverter
U5  Net-_U106-Pad2_ Net-_U10-Pad1_ adc_bridge_1
U31  Net-_U27-Pad2_ Net-_U31-Pad2_ d_inverter
U34  Net-_U31-Pad2_ Net-_U34-Pad2_ d_inverter
U20  Net-_U11-Pad1_ Net-_M4-Pad2_ dac_bridge_1
M2  Net-_M2-Pad1_ Net-_M2-Pad2_ Net-_M2-Pad3_ GND mosfet_n
M6  Net-_M2-Pad3_ Net-_M6-Pad2_ Net-_M2-Pad1_ VCC mosfet_p
U25  Net-_M2-Pad3_ Net-_U25-Pad2_ adc_bridge_1
U21  Net-_U11-Pad2_ Net-_M6-Pad2_ dac_bridge_1
U13  Net-_U13-Pad1_ Net-_M2-Pad1_ dac_bridge_1
U8  Net-_U3-Pad2_ Net-_U13-Pad1_ d_inverter
U3  Net-_U106-Pad6_ Net-_U3-Pad2_ adc_bridge_1
U29  Net-_U25-Pad2_ Net-_U29-Pad2_ d_inverter
U17  Net-_U11-Pad1_ Net-_M2-Pad2_ dac_bridge_1
U35  Net-_U34-Pad2_ Net-_U32-Pad2_ Net-_U35-Pad3_ d_nand
U51  Net-_U35-Pad3_ Net-_U29-Pad2_ Net-_U51-Pad3_ d_nand
U63  Net-_U48-Pad2_ Net-_U51-Pad3_ Net-_U45-Pad1_ d_nand
U37  Net-_U32-Pad2_ Net-_U31-Pad2_ Net-_U37-Pad3_ d_nor
U6  Net-_U1-Pad2_ Net-_U11-Pad1_ d_inverter
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ adc_bridge_1
U11  Net-_U11-Pad1_ Net-_U11-Pad2_ d_inverter
U48  Net-_U106-Pad4_ Net-_U48-Pad2_ adc_bridge_1
U72  Net-_U45-Pad1_ Net-_U40-Pad4_ Net-_U72-Pad3_ d_nor
U85  Net-_U45-Pad5_ Net-_U83-Pad2_ Net-_U85-Pad3_ d_nor
U86  Net-_U46-Pad4_ Net-_U83-Pad2_ Net-_U86-Pad3_ d_nor
U87  Net-_U72-Pad3_ Net-_U83-Pad2_ Net-_U87-Pad3_ d_nor
U88  Net-_U47-Pad5_ Net-_U83-Pad2_ Net-_U88-Pad3_ d_nor
U89  Net-_U49-Pad4_ Net-_U83-Pad2_ Net-_U89-Pad3_ d_nor
U90  Net-_U50-Pad5_ Net-_U83-Pad2_ Net-_U90-Pad3_ d_nor
U91  Net-_U52-Pad5_ Net-_U83-Pad2_ Net-_U91-Pad3_ d_nor
U83  Net-_U73-Pad2_ Net-_U83-Pad2_ d_inverter
U73  Net-_U106-Pad3_ Net-_U73-Pad2_ adc_bridge_1
U92  Net-_U85-Pad3_ Net-_U92-Pad2_ d_inverter
U93  Net-_U86-Pad3_ Net-_U100-Pad1_ d_inverter
U99  Net-_U92-Pad2_ Net-_U106-Pad13_ dac_bridge_1
U100  Net-_U100-Pad1_ Net-_U100-Pad2_ dac_bridge_1
U94  Net-_U87-Pad3_ Net-_U101-Pad1_ d_inverter
U101  Net-_U101-Pad1_ Net-_U101-Pad2_ dac_bridge_1
U95  Net-_U88-Pad3_ Net-_U102-Pad1_ d_inverter
U96  Net-_U89-Pad3_ Net-_U103-Pad1_ d_inverter
U102  Net-_U102-Pad1_ Net-_U102-Pad2_ dac_bridge_1
U103  Net-_U103-Pad1_ Net-_U103-Pad2_ dac_bridge_1
U98  Net-_U90-Pad3_ Net-_U105-Pad1_ d_inverter
U105  Net-_U105-Pad1_ Net-_U105-Pad2_ dac_bridge_1
U97  Net-_U91-Pad3_ Net-_U104-Pad1_ d_inverter
U104  Net-_U104-Pad1_ Net-_U104-Pad2_ dac_bridge_1
U106  Net-_U106-Pad1_ Net-_U106-Pad2_ Net-_U106-Pad3_ Net-_U106-Pad4_ Net-_U1-Pad1_ Net-_U106-Pad6_ Net-_U106-Pad7_ GND Net-_U103-Pad2_ Net-_U102-Pad2_ Net-_U101-Pad2_ Net-_U100-Pad2_ Net-_U106-Pad13_ Net-_U104-Pad2_ Net-_U105-Pad2_ VCC PORT
U40  Net-_U30-Pad2_ Net-_U32-Pad2_ Net-_U31-Pad2_ Net-_U40-Pad4_ nor_thre
U41  Net-_U33-Pad2_ Net-_U28-Pad2_ Net-_U31-Pad2_ Net-_U41-Pad4_ nor_thre
U42  Net-_U33-Pad2_ Net-_U32-Pad2_ Net-_U34-Pad2_ Net-_U42-Pad4_ nor_thre
U38  Net-_U33-Pad2_ Net-_U28-Pad2_ Net-_U34-Pad2_ Net-_U38-Pad4_ nor_thre
U39  Net-_U30-Pad2_ Net-_U34-Pad2_ Net-_U28-Pad2_ Net-_U39-Pad4_ nor_thre
U43  Net-_U30-Pad2_ Net-_U28-Pad2_ Net-_U31-Pad2_ Net-_U29-Pad2_ Net-_U43-Pad5_ nor_four
U44  Net-_U33-Pad2_ Net-_U28-Pad2_ Net-_U31-Pad2_ Net-_U29-Pad2_ Net-_U44-Pad5_ nor_four
U36  Net-_U30-Pad2_ Net-_U32-Pad2_ Net-_U34-Pad2_ Net-_U36-Pad4_ nor_thre
U45  Net-_U45-Pad1_ Net-_U36-Pad4_ Net-_U39-Pad4_ Net-_U44-Pad5_ Net-_U45-Pad5_ nor_four
U46  Net-_U45-Pad1_ Net-_U36-Pad4_ Net-_U38-Pad4_ Net-_U46-Pad4_ nor_thre
U47  Net-_U45-Pad1_ Net-_U42-Pad4_ Net-_U39-Pad4_ Net-_U41-Pad4_ Net-_U47-Pad5_ nor_four
U49  Net-_U45-Pad1_ Net-_U30-Pad2_ ? Net-_U49-Pad4_ nor_thre
U50  Net-_U45-Pad1_ Net-_U37-Pad3_ Net-_U42-Pad4_ Net-_U44-Pad5_ Net-_U50-Pad5_ nor_four
U52  Net-_U45-Pad1_ Net-_U42-Pad4_ Net-_U44-Pad5_ Net-_U43-Pad5_ Net-_U52-Pad5_ nor_four

.end
