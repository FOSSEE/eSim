* C:\Users\chand\esim\FOSSEE\eSim\library\SubcircuitLibrary\CD54HC374\CD54HC374.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/06/25 14:02:08

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U5  Net-_U1-Pad2_ Net-_U3-Pad2_ ? ? ? Net-_U5-Pad6_ d_dff
U6  Net-_U6-Pad1_ Net-_U10-Pad2_ Net-_U1-Pad10_ d_tristate
U3  Net-_U12-Pad1_ Net-_U3-Pad2_ d_inverter
U7  Net-_U5-Pad6_ Net-_U6-Pad1_ d_inverter
U4  Net-_U1-Pad18_ Net-_U10-Pad2_ d_inverter
U9  Net-_U1-Pad3_ Net-_U8-Pad2_ ? ? ? Net-_U11-Pad1_ d_dff
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ Net-_U1-Pad11_ d_tristate
U8  Net-_U12-Pad1_ Net-_U8-Pad2_ d_inverter
U11  Net-_U11-Pad1_ Net-_U10-Pad1_ d_inverter
U13  Net-_U1-Pad4_ Net-_U12-Pad2_ ? ? ? Net-_U13-Pad6_ d_dff
U14  Net-_U14-Pad1_ Net-_U10-Pad2_ Net-_U1-Pad12_ d_tristate
U12  Net-_U12-Pad1_ Net-_U12-Pad2_ d_inverter
U15  Net-_U13-Pad6_ Net-_U14-Pad1_ d_inverter
U17  Net-_U1-Pad5_ Net-_U16-Pad2_ ? ? ? Net-_U17-Pad6_ d_dff
U18  Net-_U18-Pad1_ Net-_U10-Pad2_ Net-_U1-Pad13_ d_tristate
U16  Net-_U12-Pad1_ Net-_U16-Pad2_ d_inverter
U19  Net-_U17-Pad6_ Net-_U18-Pad1_ d_inverter
U21  Net-_U1-Pad6_ Net-_U20-Pad2_ ? ? ? Net-_U21-Pad6_ d_dff
U22  Net-_U22-Pad1_ Net-_U10-Pad2_ Net-_U1-Pad14_ d_tristate
U20  Net-_U12-Pad1_ Net-_U20-Pad2_ d_inverter
U23  Net-_U21-Pad6_ Net-_U22-Pad1_ d_inverter
U25  Net-_U1-Pad7_ Net-_U24-Pad2_ ? ? ? Net-_U25-Pad6_ d_dff
U26  Net-_U26-Pad1_ Net-_U10-Pad2_ Net-_U1-Pad15_ d_tristate
U24  Net-_U12-Pad1_ Net-_U24-Pad2_ d_inverter
U27  Net-_U25-Pad6_ Net-_U26-Pad1_ d_inverter
U29  Net-_U1-Pad8_ Net-_U28-Pad2_ ? ? ? Net-_U29-Pad6_ d_dff
U30  Net-_U30-Pad1_ Net-_U10-Pad2_ Net-_U1-Pad16_ d_tristate
U28  Net-_U12-Pad1_ Net-_U28-Pad2_ d_inverter
U31  Net-_U29-Pad6_ Net-_U30-Pad1_ d_inverter
U33  Net-_U1-Pad9_ Net-_U32-Pad2_ ? ? ? Net-_U33-Pad6_ d_dff
U34  Net-_U34-Pad1_ Net-_U10-Pad2_ Net-_U1-Pad17_ d_tristate
U32  Net-_U12-Pad1_ Net-_U32-Pad2_ d_inverter
U35  Net-_U33-Pad6_ Net-_U34-Pad1_ d_inverter
U2  Net-_U1-Pad1_ Net-_U12-Pad1_ d_inverter
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ Net-_U1-Pad16_ Net-_U1-Pad17_ Net-_U1-Pad18_ PORT

.end
