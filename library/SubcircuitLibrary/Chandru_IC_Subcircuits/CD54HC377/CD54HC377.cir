* C:\Users\chand\esim\FOSSEE\eSim\library\SubcircuitLibrary\CD54HC377\CD54HC377.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 05/29/25 11:28:30

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U3  Net-_U2-Pad1_ Net-_U3-Pad2_ d_inverter
U8  Net-_U2-Pad2_ Net-_U10-Pad1_ Net-_U8-Pad3_ d_and
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ d_inverter
U11  Net-_U1-Pad3_ Net-_U10-Pad2_ Net-_U11-Pad3_ d_and
U12  Net-_U12-Pad1_ Net-_U10-Pad1_ Net-_U12-Pad3_ d_and
U15  Net-_U10-Pad1_ Net-_U15-Pad2_ d_inverter
U16  Net-_U16-Pad1_ Net-_U15-Pad2_ Net-_U13-Pad1_ d_and
U17  Net-_U17-Pad1_ Net-_U10-Pad1_ Net-_U17-Pad3_ d_and
U19  Net-_U10-Pad1_ Net-_U19-Pad2_ d_inverter
U20  Net-_U2-Pad12_ Net-_U19-Pad2_ Net-_U18-Pad1_ d_and
U21  Net-_U2-Pad5_ Net-_U10-Pad1_ Net-_U21-Pad3_ d_and
U24  Net-_U10-Pad1_ Net-_U24-Pad2_ d_inverter
U25  Net-_U14-Pad3_ Net-_U24-Pad2_ Net-_U22-Pad1_ d_and
U26  Net-_U2-Pad6_ Net-_U10-Pad1_ Net-_U26-Pad3_ d_and
U28  Net-_U10-Pad1_ Net-_U28-Pad2_ d_inverter
U29  Net-_U2-Pad14_ Net-_U28-Pad2_ Net-_U27-Pad1_ d_and
U30  Net-_U2-Pad7_ Net-_U10-Pad1_ Net-_U30-Pad3_ d_and
U33  Net-_U10-Pad1_ Net-_U33-Pad2_ d_inverter
U34  Net-_U2-Pad15_ Net-_U33-Pad2_ Net-_U31-Pad1_ d_and
U35  Net-_U2-Pad8_ Net-_U10-Pad1_ Net-_U35-Pad3_ d_and
U37  Net-_U10-Pad1_ Net-_U37-Pad2_ d_inverter
U38  Net-_U2-Pad16_ Net-_U37-Pad2_ Net-_U36-Pad1_ d_and
U40  Net-_U2-Pad9_ Net-_U10-Pad1_ Net-_U40-Pad3_ d_and
U43  Net-_U10-Pad1_ Net-_U43-Pad2_ d_inverter
U44  Net-_U2-Pad17_ Net-_U43-Pad2_ Net-_U42-Pad1_ d_and
U9  Net-_U11-Pad3_ Net-_U8-Pad3_ Net-_U1-Pad1_ d_or
U13  Net-_U13-Pad1_ Net-_U12-Pad3_ Net-_U13-Pad3_ d_or
U18  Net-_U18-Pad1_ Net-_U17-Pad3_ Net-_U18-Pad3_ d_or
U22  Net-_U22-Pad1_ Net-_U21-Pad3_ Net-_U14-Pad1_ d_or
U27  Net-_U27-Pad1_ Net-_U26-Pad3_ Net-_U23-Pad1_ d_or
U31  Net-_U31-Pad1_ Net-_U30-Pad3_ Net-_U31-Pad3_ d_or
U36  Net-_U36-Pad1_ Net-_U35-Pad3_ Net-_U36-Pad3_ d_or
U42  Net-_U42-Pad1_ Net-_U40-Pad3_ Net-_U39-Pad1_ d_or
U6  Net-_U3-Pad2_ Net-_U10-Pad1_ d_buffer
U5  Net-_U2-Pad18_ Net-_U1-Pad2_ d_inverter
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ risingedge_dflipflop
U7  Net-_U18-Pad3_ Net-_U1-Pad2_ Net-_U2-Pad12_ risingedge_dflipflop
U14  Net-_U14-Pad1_ Net-_U1-Pad2_ Net-_U14-Pad3_ risingedge_dflipflop
U23  Net-_U23-Pad1_ Net-_U1-Pad2_ Net-_U2-Pad14_ risingedge_dflipflop
U32  Net-_U31-Pad3_ Net-_U1-Pad2_ Net-_U2-Pad15_ risingedge_dflipflop
U4  Net-_U13-Pad3_ Net-_U1-Pad2_ Net-_U16-Pad1_ risingedge_dflipflop
U41  Net-_U36-Pad3_ Net-_U1-Pad2_ Net-_U2-Pad16_ risingedge_dflipflop
U39  Net-_U39-Pad1_ Net-_U1-Pad2_ Net-_U2-Pad17_ risingedge_dflipflop
U2  Net-_U2-Pad1_ Net-_U2-Pad2_ Net-_U12-Pad1_ Net-_U17-Pad1_ Net-_U2-Pad5_ Net-_U2-Pad6_ Net-_U2-Pad7_ Net-_U2-Pad8_ Net-_U2-Pad9_ Net-_U1-Pad3_ Net-_U16-Pad1_ Net-_U2-Pad12_ Net-_U14-Pad3_ Net-_U2-Pad14_ Net-_U2-Pad15_ Net-_U2-Pad16_ Net-_U2-Pad17_ Net-_U2-Pad18_ PORT

.end
