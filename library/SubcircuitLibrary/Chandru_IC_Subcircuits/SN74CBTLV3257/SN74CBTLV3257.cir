* C:\Users\chand\esim\FOSSEE\eSim\library\SubcircuitLibrary\SN74CBTLV3257\SN74CBTLV3257.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/24/25 23:39:48

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
M1  Net-_M1-Pad1_ Net-_M1-Pad2_ Net-_M1-Pad3_ GND mosfet_n
M3  Net-_M1-Pad3_ Net-_M3-Pad2_ Net-_M1-Pad1_ VCC mosfet_p
U1  Net-_U1-Pad1_ Net-_M1-Pad1_ Net-_M11-Pad3_ Net-_U1-Pad4_ Net-_M2-Pad1_ Net-_M10-Pad1_ Net-_U1-Pad7_ GND Net-_U1-Pad9_ Net-_M12-Pad1_ Net-_M4-Pad1_ Net-_U1-Pad12_ Net-_M14-Pad1_ Net-_M6-Pad1_ Net-_U1-Pad15_ VCC PORT
U3  Net-_U13-Pad1_ Net-_U3-Pad2_ d_inverter
U4  Net-_U3-Pad2_ Net-_M3-Pad2_ dac_bridge_1
U13  Net-_U13-Pad1_ Net-_M1-Pad2_ dac_bridge_1
M9  Net-_M11-Pad3_ Net-_M9-Pad2_ Net-_M1-Pad3_ GND mosfet_n
M11  Net-_M1-Pad3_ Net-_M11-Pad2_ Net-_M11-Pad3_ VCC mosfet_p
U19  Net-_U18-Pad3_ Net-_U19-Pad2_ d_inverter
U20  Net-_U19-Pad2_ Net-_M11-Pad2_ dac_bridge_1
U27  Net-_U18-Pad3_ Net-_M9-Pad2_ dac_bridge_1
M2  Net-_M2-Pad1_ Net-_M2-Pad2_ Net-_M10-Pad3_ GND mosfet_n
M5  Net-_M10-Pad3_ Net-_M5-Pad2_ Net-_M2-Pad1_ VCC mosfet_p
U5  Net-_U13-Pad1_ Net-_U5-Pad2_ d_inverter
U7  Net-_U5-Pad2_ Net-_M5-Pad2_ dac_bridge_1
U14  Net-_U13-Pad1_ Net-_M2-Pad2_ dac_bridge_1
M10  Net-_M10-Pad1_ Net-_M10-Pad2_ Net-_M10-Pad3_ GND mosfet_n
M13  Net-_M10-Pad3_ Net-_M13-Pad2_ Net-_M10-Pad1_ VCC mosfet_p
U21  Net-_U18-Pad3_ Net-_U21-Pad2_ d_inverter
U23  Net-_U21-Pad2_ Net-_M13-Pad2_ dac_bridge_1
U28  Net-_U18-Pad3_ Net-_M10-Pad2_ dac_bridge_1
M4  Net-_M4-Pad1_ Net-_M4-Pad2_ Net-_M12-Pad3_ GND mosfet_n
M7  Net-_M12-Pad3_ Net-_M7-Pad2_ Net-_M4-Pad1_ VCC mosfet_p
U6  Net-_U13-Pad1_ Net-_U6-Pad2_ d_inverter
U8  Net-_U6-Pad2_ Net-_M7-Pad2_ dac_bridge_1
U15  Net-_U13-Pad1_ Net-_M4-Pad2_ dac_bridge_1
M12  Net-_M12-Pad1_ Net-_M12-Pad2_ Net-_M12-Pad3_ GND mosfet_n
M15  Net-_M12-Pad3_ Net-_M15-Pad2_ Net-_M12-Pad1_ VCC mosfet_p
U22  Net-_U18-Pad3_ Net-_U22-Pad2_ d_inverter
U24  Net-_U22-Pad2_ Net-_M15-Pad2_ dac_bridge_1
U29  Net-_U18-Pad3_ Net-_M12-Pad2_ dac_bridge_1
M6  Net-_M6-Pad1_ Net-_M6-Pad2_ Net-_M14-Pad3_ GND mosfet_n
M8  Net-_M14-Pad3_ Net-_M8-Pad2_ Net-_M6-Pad1_ VCC mosfet_p
U9  Net-_U13-Pad1_ Net-_U10-Pad1_ d_inverter
U10  Net-_U10-Pad1_ Net-_M8-Pad2_ dac_bridge_1
U16  Net-_U13-Pad1_ Net-_M6-Pad2_ dac_bridge_1
M14  Net-_M14-Pad1_ Net-_M14-Pad2_ Net-_M14-Pad3_ GND mosfet_n
M16  Net-_M14-Pad3_ Net-_M16-Pad2_ Net-_M14-Pad1_ VCC mosfet_p
U25  Net-_U18-Pad3_ Net-_U25-Pad2_ d_inverter
U26  Net-_U25-Pad2_ Net-_M16-Pad2_ dac_bridge_1
U30  Net-_U18-Pad3_ Net-_M14-Pad2_ dac_bridge_1
U17  Net-_U11-Pad2_ Net-_U12-Pad2_ Net-_U13-Pad1_ d_and
U18  Net-_U11-Pad1_ Net-_U12-Pad2_ Net-_U18-Pad3_ d_and
U11  Net-_U11-Pad1_ Net-_U11-Pad2_ d_inverter
U12  Net-_U12-Pad1_ Net-_U12-Pad2_ d_inverter
U2  Net-_U1-Pad1_ Net-_U1-Pad15_ Net-_U11-Pad1_ Net-_U12-Pad1_ adc_bridge_2
U35  Net-_U31-Pad2_ Net-_U35-Pad2_ d_buffer
U31  Net-_M1-Pad3_ Net-_U31-Pad2_ adc_bridge_1
U39  Net-_U35-Pad2_ Net-_U1-Pad4_ dac_bridge_1
U38  Net-_U34-Pad2_ Net-_U38-Pad2_ d_buffer
U34  Net-_M10-Pad3_ Net-_U34-Pad2_ adc_bridge_1
U42  Net-_U38-Pad2_ Net-_U1-Pad7_ dac_bridge_1
U36  Net-_U32-Pad2_ Net-_U36-Pad2_ d_buffer
U32  Net-_M12-Pad3_ Net-_U32-Pad2_ adc_bridge_1
U40  Net-_U36-Pad2_ Net-_U1-Pad9_ dac_bridge_1
U37  Net-_U33-Pad2_ Net-_U37-Pad2_ d_buffer
U33  Net-_M14-Pad3_ Net-_U33-Pad2_ adc_bridge_1
U41  Net-_U37-Pad2_ Net-_U1-Pad12_ dac_bridge_1

.end
