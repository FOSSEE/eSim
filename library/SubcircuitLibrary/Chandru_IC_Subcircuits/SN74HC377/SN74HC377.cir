* C:\Users\chand\esim\FOSSEE\eSim\library\SubcircuitLibrary\SN74HC377\SN74HC377.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/02/25 14:55:03

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U10  Net-_U1-Pad1_ Net-_U10-Pad2_ d_inverter
U12  Net-_U10-Pad2_ Net-_U12-Pad2_ d_inverter
U14  Net-_U12-Pad2_ Net-_U14-Pad2_ Net-_U14-Pad3_ d_nor
U11  Net-_U1-Pad18_ Net-_U11-Pad2_ d_inverter
U13  Net-_U11-Pad2_ Net-_U13-Pad2_ d_buffer
U15  Net-_U14-Pad3_ Net-_U13-Pad2_ Net-_U14-Pad2_ d_nor
U16  Net-_U14-Pad3_ Net-_U1-Pad18_ Net-_U16-Pad3_ d_and
U2  Net-_U1-Pad2_ Net-_U16-Pad3_ Net-_U1-Pad17_ risingedge_dflipflop
U3  Net-_U1-Pad3_ Net-_U16-Pad3_ Net-_U1-Pad16_ risingedge_dflipflop
U4  Net-_U1-Pad4_ Net-_U16-Pad3_ Net-_U1-Pad15_ risingedge_dflipflop
U5  Net-_U1-Pad5_ Net-_U16-Pad3_ Net-_U1-Pad14_ risingedge_dflipflop
U6  Net-_U1-Pad6_ Net-_U16-Pad3_ Net-_U1-Pad13_ risingedge_dflipflop
U7  Net-_U1-Pad7_ Net-_U16-Pad3_ Net-_U1-Pad12_ risingedge_dflipflop
U8  Net-_U1-Pad8_ Net-_U16-Pad3_ Net-_U1-Pad11_ risingedge_dflipflop
U9  Net-_U1-Pad9_ Net-_U16-Pad3_ Net-_U1-Pad10_ risingedge_dflipflop
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ Net-_U1-Pad16_ Net-_U1-Pad17_ Net-_U1-Pad18_ PORT

.end
