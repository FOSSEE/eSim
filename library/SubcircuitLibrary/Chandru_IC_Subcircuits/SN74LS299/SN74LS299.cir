* C:\Users\chand\esim\FOSSEE\eSim\library\SubcircuitLibrary\SN74LS299\SN74LS299.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/05/25 16:04:03

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
X2  Net-_U8-Pad2_ Net-_U12-Pad2_ Net-_U1-Pad7_ Net-_X2-Pad4_ 3_and
X3  Net-_U13-Pad4_ Net-_U11-Pad2_ Net-_U9-Pad2_ Net-_X3-Pad4_ 3_and
X5  Net-_U1-Pad9_ Net-_U12-Pad2_ Net-_U9-Pad2_ Net-_X4-Pad2_ 3_and
X6  Net-_U1-Pad8_ Net-_U11-Pad2_ Net-_U8-Pad2_ Net-_X4-Pad1_ 3_and
X4  Net-_X4-Pad1_ Net-_X4-Pad2_ Net-_X3-Pad4_ Net-_X2-Pad4_ Net-_U2-Pad2_ 4_OR
U2  Net-_U1-Pad3_ Net-_U2-Pad2_ Net-_U13-Pad3_ Net-_U1-Pad8_ ? d_flip_flop
U3  Net-_U1-Pad8_ Net-_U14-Pad2_ Net-_U1-Pad9_ buffer_test
U8  Net-_U1-Pad2_ Net-_U8-Pad2_ d_inverter
U9  Net-_U8-Pad2_ Net-_U9-Pad2_ d_inverter
U11  Net-_U1-Pad1_ Net-_U11-Pad2_ d_inverter
U12  Net-_U11-Pad2_ Net-_U12-Pad2_ d_inverter
X7  Net-_U8-Pad2_ Net-_U12-Pad2_ Net-_U1-Pad8_ Net-_X7-Pad4_ 3_and
X8  Net-_U15-Pad4_ Net-_U11-Pad2_ Net-_U9-Pad2_ Net-_X8-Pad4_ 3_and
X10  Net-_U1-Pad10_ Net-_U12-Pad2_ Net-_U9-Pad2_ Net-_X10-Pad4_ 3_and
X11  Net-_U13-Pad4_ Net-_U11-Pad2_ Net-_U8-Pad2_ Net-_X11-Pad4_ 3_and
X9  Net-_X11-Pad4_ Net-_X10-Pad4_ Net-_X8-Pad4_ Net-_X7-Pad4_ Net-_U13-Pad2_ 4_OR
U13  Net-_U1-Pad3_ Net-_U13-Pad2_ Net-_U13-Pad3_ Net-_U13-Pad4_ ? d_flip_flop
U14  Net-_U13-Pad4_ Net-_U14-Pad2_ Net-_U1-Pad10_ buffer_test
X12  Net-_U8-Pad2_ Net-_U12-Pad2_ Net-_U13-Pad4_ Net-_X12-Pad4_ 3_and
X13  Net-_U17-Pad4_ Net-_U11-Pad2_ Net-_U9-Pad2_ Net-_X13-Pad4_ 3_and
X15  Net-_U1-Pad11_ Net-_U12-Pad2_ Net-_U9-Pad2_ Net-_X14-Pad2_ 3_and
X16  Net-_U15-Pad4_ Net-_U11-Pad2_ Net-_U8-Pad2_ Net-_X14-Pad1_ 3_and
X14  Net-_X14-Pad1_ Net-_X14-Pad2_ Net-_X13-Pad4_ Net-_X12-Pad4_ Net-_U15-Pad2_ 4_OR
U15  Net-_U1-Pad3_ Net-_U15-Pad2_ Net-_U13-Pad3_ Net-_U15-Pad4_ ? d_flip_flop
U16  Net-_U15-Pad4_ Net-_U14-Pad2_ Net-_U1-Pad11_ buffer_test
X17  Net-_U8-Pad2_ Net-_U12-Pad2_ Net-_U15-Pad4_ Net-_X17-Pad4_ 3_and
X18  Net-_U19-Pad4_ Net-_U11-Pad2_ Net-_U9-Pad2_ Net-_X18-Pad4_ 3_and
X20  Net-_U1-Pad12_ Net-_U12-Pad2_ Net-_U9-Pad2_ Net-_X19-Pad2_ 3_and
X21  Net-_U17-Pad4_ Net-_U11-Pad2_ Net-_U8-Pad2_ Net-_X19-Pad1_ 3_and
X19  Net-_X19-Pad1_ Net-_X19-Pad2_ Net-_X18-Pad4_ Net-_X17-Pad4_ Net-_U17-Pad2_ 4_OR
U17  Net-_U1-Pad3_ Net-_U17-Pad2_ Net-_U13-Pad3_ Net-_U17-Pad4_ ? d_flip_flop
U18  Net-_U17-Pad4_ Net-_U14-Pad2_ Net-_U1-Pad12_ buffer_test
X22  Net-_U8-Pad2_ Net-_U12-Pad2_ Net-_U17-Pad4_ Net-_X22-Pad4_ 3_and
X23  Net-_U21-Pad4_ Net-_U11-Pad2_ Net-_U9-Pad2_ Net-_X23-Pad4_ 3_and
X25  Net-_U1-Pad13_ Net-_U12-Pad2_ Net-_U9-Pad2_ Net-_X24-Pad2_ 3_and
X26  Net-_U19-Pad4_ Net-_U11-Pad2_ Net-_U8-Pad2_ Net-_X24-Pad1_ 3_and
X24  Net-_X24-Pad1_ Net-_X24-Pad2_ Net-_X23-Pad4_ Net-_X22-Pad4_ Net-_U19-Pad2_ 4_OR
U19  Net-_U1-Pad3_ Net-_U19-Pad2_ Net-_U13-Pad3_ Net-_U19-Pad4_ ? d_flip_flop
U20  Net-_U19-Pad4_ Net-_U14-Pad2_ Net-_U1-Pad13_ buffer_test
X27  Net-_U8-Pad2_ Net-_U12-Pad2_ Net-_U19-Pad4_ Net-_X27-Pad4_ 3_and
X28  Net-_U23-Pad4_ Net-_U11-Pad2_ Net-_U9-Pad2_ Net-_X28-Pad4_ 3_and
X30  Net-_U1-Pad14_ Net-_U12-Pad2_ Net-_U9-Pad2_ Net-_X29-Pad2_ 3_and
X31  Net-_U21-Pad4_ Net-_U11-Pad2_ Net-_U8-Pad2_ Net-_X29-Pad1_ 3_and
X29  Net-_X29-Pad1_ Net-_X29-Pad2_ Net-_X28-Pad4_ Net-_X27-Pad4_ Net-_U21-Pad2_ 4_OR
U21  Net-_U1-Pad3_ Net-_U21-Pad2_ Net-_U13-Pad3_ Net-_U21-Pad4_ ? d_flip_flop
U22  Net-_U21-Pad4_ Net-_U14-Pad2_ Net-_U1-Pad14_ buffer_test
X32  Net-_U8-Pad2_ Net-_U12-Pad2_ Net-_U21-Pad4_ Net-_X32-Pad4_ 3_and
X33  Net-_U1-Pad17_ Net-_U11-Pad2_ Net-_U9-Pad2_ Net-_X33-Pad4_ 3_and
X35  Net-_U1-Pad15_ Net-_U12-Pad2_ Net-_U9-Pad2_ Net-_X34-Pad2_ 3_and
X36  Net-_U23-Pad4_ Net-_U11-Pad2_ Net-_U8-Pad2_ Net-_X34-Pad1_ 3_and
X34  Net-_X34-Pad1_ Net-_X34-Pad2_ Net-_X33-Pad4_ Net-_X32-Pad4_ Net-_U23-Pad2_ 4_OR
U23  Net-_U1-Pad3_ Net-_U23-Pad2_ Net-_U13-Pad3_ Net-_U23-Pad4_ ? d_flip_flop
U24  Net-_U23-Pad4_ Net-_U14-Pad2_ Net-_U1-Pad15_ buffer_test
X37  Net-_U8-Pad2_ Net-_U12-Pad2_ Net-_U23-Pad4_ Net-_X37-Pad4_ 3_and
X38  Net-_U1-Pad18_ Net-_U11-Pad2_ Net-_U9-Pad2_ Net-_X38-Pad4_ 3_and
X40  Net-_U1-Pad16_ Net-_U12-Pad2_ Net-_U9-Pad2_ Net-_X39-Pad2_ 3_and
X41  Net-_U1-Pad17_ Net-_U11-Pad2_ Net-_U8-Pad2_ Net-_X39-Pad1_ 3_and
X39  Net-_X39-Pad1_ Net-_X39-Pad2_ Net-_X38-Pad4_ Net-_X37-Pad4_ Net-_U25-Pad2_ 4_OR
U25  Net-_U1-Pad3_ Net-_U25-Pad2_ Net-_U13-Pad3_ Net-_U1-Pad17_ ? d_flip_flop
U26  Net-_U1-Pad17_ Net-_U14-Pad2_ Net-_U1-Pad16_ buffer_test
U7  Net-_U1-Pad6_ Net-_U13-Pad3_ d_inverter
X1  Net-_U4-Pad2_ Net-_U5-Pad2_ Net-_U6-Pad2_ Net-_U14-Pad2_ 3_and
U6  Net-_U1-Pad5_ Net-_U6-Pad2_ d_inverter
U5  Net-_U1-Pad4_ Net-_U5-Pad2_ d_inverter
U4  Net-_U10-Pad3_ Net-_U4-Pad2_ d_inverter
U10  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U10-Pad3_ d_and
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ Net-_U1-Pad16_ Net-_U1-Pad17_ Net-_U1-Pad18_ PORT

.end
