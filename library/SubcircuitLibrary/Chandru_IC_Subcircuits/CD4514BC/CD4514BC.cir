* C:\Users\chand\esim\FOSSEE\eSim\library\SubcircuitLibrary\CD4514BC\CD4514BC.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 07/08/25 18:14:37

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U24  Net-_U24-Pad1_ Net-_U24-Pad2_ Net-_U16-Pad1_ d_and
U8  Net-_U3-Pad2_ Net-_U24-Pad1_ d_inverter
U9  Net-_U11-Pad1_ Net-_U24-Pad2_ d_inverter
U28  Net-_U16-Pad2_ Net-_U17-Pad2_ Net-_U28-Pad3_ d_and
U16  Net-_U16-Pad1_ Net-_U16-Pad2_ d_inverter
U17  Net-_U11-Pad1_ Net-_U17-Pad2_ d_inverter
U3  Net-_U1-Pad4_ Net-_U3-Pad2_ d_inverter
U52  Net-_U36-Pad2_ Net-_U37-Pad2_ Net-_U52-Pad3_ d_and
U36  Net-_U32-Pad6_ Net-_U36-Pad2_ d_inverter
U37  Net-_U33-Pad6_ Net-_U37-Pad2_ d_inverter
U53  Net-_U38-Pad2_ Net-_U39-Pad2_ Net-_U53-Pad3_ d_and
U38  Net-_U32-Pad7_ Net-_U38-Pad2_ d_inverter
U39  Net-_U33-Pad6_ Net-_U39-Pad2_ d_inverter
U25  Net-_U10-Pad2_ Net-_U11-Pad2_ Net-_U18-Pad1_ d_and
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ d_inverter
U11  Net-_U11-Pad1_ Net-_U11-Pad2_ d_inverter
U29  Net-_U18-Pad2_ Net-_U19-Pad2_ Net-_U29-Pad3_ d_and
U18  Net-_U18-Pad1_ Net-_U18-Pad2_ d_inverter
U19  Net-_U11-Pad1_ Net-_U19-Pad2_ d_inverter
U4  Net-_U1-Pad5_ Net-_U10-Pad1_ d_inverter
U54  Net-_U40-Pad2_ Net-_U41-Pad2_ Net-_U54-Pad3_ d_and
U40  Net-_U32-Pad6_ Net-_U40-Pad2_ d_inverter
U41  Net-_U33-Pad7_ Net-_U41-Pad2_ d_inverter
U55  Net-_U42-Pad2_ Net-_U43-Pad2_ Net-_U55-Pad3_ d_and
U42  Net-_U32-Pad7_ Net-_U42-Pad2_ d_inverter
U43  Net-_U33-Pad7_ Net-_U43-Pad2_ d_inverter
U26  Net-_U12-Pad2_ Net-_U13-Pad2_ Net-_U20-Pad1_ d_and
U12  Net-_U12-Pad1_ Net-_U12-Pad2_ d_inverter
U13  Net-_U11-Pad1_ Net-_U13-Pad2_ d_inverter
U30  Net-_U20-Pad2_ Net-_U21-Pad2_ Net-_U30-Pad3_ d_and
U20  Net-_U20-Pad1_ Net-_U20-Pad2_ d_inverter
U21  Net-_U11-Pad1_ Net-_U21-Pad2_ d_inverter
U5  Net-_U1-Pad6_ Net-_U12-Pad1_ d_inverter
U56  Net-_U44-Pad2_ Net-_U45-Pad2_ Net-_U56-Pad3_ d_and
U44  Net-_U34-Pad6_ Net-_U44-Pad2_ d_inverter
U45  Net-_U35-Pad6_ Net-_U45-Pad2_ d_inverter
U57  Net-_U46-Pad2_ Net-_U47-Pad2_ Net-_U57-Pad3_ d_and
U46  Net-_U34-Pad7_ Net-_U46-Pad2_ d_inverter
U47  Net-_U35-Pad6_ Net-_U47-Pad2_ d_inverter
U27  Net-_U14-Pad2_ Net-_U15-Pad2_ Net-_U22-Pad1_ d_and
U14  Net-_U14-Pad1_ Net-_U14-Pad2_ d_inverter
U15  Net-_U11-Pad1_ Net-_U15-Pad2_ d_inverter
U31  Net-_U22-Pad2_ Net-_U23-Pad2_ Net-_U31-Pad3_ d_and
U22  Net-_U22-Pad1_ Net-_U22-Pad2_ d_inverter
U23  Net-_U11-Pad1_ Net-_U23-Pad2_ d_inverter
U6  Net-_U1-Pad7_ Net-_U14-Pad1_ d_inverter
U58  Net-_U48-Pad2_ Net-_U49-Pad2_ Net-_U58-Pad3_ d_and
U48  Net-_U34-Pad6_ Net-_U48-Pad2_ d_inverter
U49  Net-_U35-Pad7_ Net-_U49-Pad2_ d_inverter
U59  Net-_U50-Pad2_ Net-_U51-Pad2_ Net-_U59-Pad3_ d_and
U50  Net-_U34-Pad7_ Net-_U50-Pad2_ d_inverter
U51  Net-_U35-Pad7_ Net-_U51-Pad2_ d_inverter
U61  Net-_U56-Pad3_ Net-_U53-Pad3_ Net-_U61-Pad3_ d_nand
U77  Net-_U61-Pad3_ Net-_U7-Pad2_ Net-_U1-Pad9_ d_nand
U60  Net-_U56-Pad3_ Net-_U52-Pad3_ Net-_U60-Pad3_ d_nand
U76  Net-_U60-Pad3_ Net-_U7-Pad2_ Net-_U1-Pad8_ d_nand
U63  Net-_U56-Pad3_ Net-_U55-Pad3_ Net-_U63-Pad3_ d_nand
U79  Net-_U63-Pad3_ Net-_U7-Pad2_ Net-_U1-Pad11_ d_nand
U62  Net-_U56-Pad3_ Net-_U54-Pad3_ Net-_U62-Pad3_ d_nand
U78  Net-_U62-Pad3_ Net-_U7-Pad2_ Net-_U1-Pad10_ d_nand
U65  Net-_U57-Pad3_ Net-_U53-Pad3_ Net-_U65-Pad3_ d_nand
U81  Net-_U65-Pad3_ Net-_U7-Pad2_ Net-_U1-Pad13_ d_nand
U64  Net-_U57-Pad3_ Net-_U52-Pad3_ Net-_U64-Pad3_ d_nand
U80  Net-_U64-Pad3_ Net-_U7-Pad2_ Net-_U1-Pad12_ d_nand
U67  Net-_U57-Pad3_ Net-_U55-Pad3_ Net-_U67-Pad3_ d_nand
U83  Net-_U67-Pad3_ Net-_U7-Pad2_ Net-_U1-Pad15_ d_nand
U66  Net-_U57-Pad3_ Net-_U54-Pad3_ Net-_U66-Pad3_ d_nand
U82  Net-_U66-Pad3_ Net-_U7-Pad2_ Net-_U1-Pad14_ d_nand
U69  Net-_U58-Pad3_ Net-_U53-Pad3_ Net-_U69-Pad3_ d_nand
U85  Net-_U69-Pad3_ Net-_U7-Pad2_ Net-_U1-Pad17_ d_nand
U68  Net-_U58-Pad3_ Net-_U52-Pad3_ Net-_U68-Pad3_ d_nand
U84  Net-_U68-Pad3_ Net-_U7-Pad2_ Net-_U1-Pad16_ d_nand
U71  Net-_U58-Pad3_ Net-_U55-Pad3_ Net-_U71-Pad3_ d_nand
U87  Net-_U71-Pad3_ Net-_U7-Pad2_ Net-_U1-Pad19_ d_nand
U70  Net-_U58-Pad3_ Net-_U54-Pad3_ Net-_U70-Pad3_ d_nand
U86  Net-_U70-Pad3_ Net-_U7-Pad2_ Net-_U1-Pad18_ d_nand
U73  Net-_U59-Pad3_ Net-_U53-Pad3_ Net-_U73-Pad3_ d_nand
U89  Net-_U73-Pad3_ Net-_U7-Pad2_ Net-_U1-Pad21_ d_nand
U72  Net-_U59-Pad3_ Net-_U52-Pad3_ Net-_U72-Pad3_ d_nand
U88  Net-_U72-Pad3_ Net-_U7-Pad2_ Net-_U1-Pad20_ d_nand
U75  Net-_U59-Pad3_ Net-_U55-Pad3_ Net-_U75-Pad3_ d_nand
U91  Net-_U75-Pad3_ Net-_U7-Pad2_ Net-_U1-Pad23_ d_nand
U74  Net-_U59-Pad3_ Net-_U54-Pad3_ Net-_U74-Pad3_ d_nand
U90  Net-_U74-Pad3_ Net-_U7-Pad2_ Net-_U1-Pad22_ d_nand
U7  Net-_U1-Pad3_ Net-_U7-Pad2_ d_inverter
U2  Net-_U1-Pad2_ Net-_U11-Pad1_ d_inverter
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ Net-_U1-Pad16_ Net-_U1-Pad17_ Net-_U1-Pad18_ Net-_U1-Pad19_ Net-_U1-Pad20_ Net-_U1-Pad21_ Net-_U1-Pad22_ Net-_U1-Pad23_ ? PORT
U35  Net-_U22-Pad1_ Net-_U31-Pad3_ Net-_U1-Pad1_ ? ? Net-_U35-Pad6_ Net-_U35-Pad7_ d_srff
U34  Net-_U20-Pad1_ Net-_U30-Pad3_ Net-_U1-Pad1_ ? ? Net-_U34-Pad6_ Net-_U34-Pad7_ d_srff
U33  Net-_U18-Pad1_ Net-_U29-Pad3_ Net-_U1-Pad1_ ? ? Net-_U33-Pad6_ Net-_U33-Pad7_ d_srff
U32  Net-_U16-Pad1_ Net-_U28-Pad3_ Net-_U1-Pad1_ ? ? Net-_U32-Pad6_ Net-_U32-Pad7_ d_srff

.end
