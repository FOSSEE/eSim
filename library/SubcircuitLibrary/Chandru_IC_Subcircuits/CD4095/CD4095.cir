* C:\Users\chand\esim\FOSSEE\eSim\library\SubcircuitLibrary\CD4095\CD4095.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 07/08/25 19:10:18

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U6  Net-_U25-Pad13_ Net-_U16-Pad1_ d_inverter
X2  Net-_U25-Pad3_ Net-_U25-Pad4_ Net-_U25-Pad5_ Net-_U8-Pad1_ 3_and
U8  Net-_U8-Pad1_ Net-_U20-Pad3_ Net-_U11-Pad1_ d_or
U9  Net-_U4-Pad2_ Net-_U5-Pad2_ Net-_U11-Pad2_ d_or
U4  Net-_U20-Pad3_ Net-_U4-Pad2_ d_inverter
U5  Net-_U5-Pad1_ Net-_U5-Pad2_ d_inverter
U11  Net-_U11-Pad1_ Net-_U11-Pad2_ Net-_U10-Pad1_ d_and
U13  Net-_U12-Pad2_ Net-_U13-Pad2_ Net-_U13-Pad3_ d_nand
U20  Net-_U18-Pad2_ Net-_U19-Pad2_ Net-_U20-Pad3_ d_or
U18  Net-_U16-Pad1_ Net-_U18-Pad2_ d_inverter
U19  Net-_U19-Pad1_ Net-_U19-Pad2_ d_inverter
U15  Net-_U14-Pad2_ Net-_U15-Pad2_ Net-_U15-Pad3_ d_or
U14  Net-_U13-Pad3_ Net-_U14-Pad2_ d_inverter
U16  Net-_U16-Pad1_ Net-_U15-Pad2_ d_inverter
U21  Net-_U20-Pad3_ Net-_U13-Pad2_ Net-_U21-Pad3_ d_nand
U3  Net-_U25-Pad2_ Net-_U13-Pad2_ d_inverter
U7  Net-_U2-Pad2_ Net-_U32-Pad1_ d_inverter
X1  Net-_U25-Pad11_ Net-_U25-Pad10_ Net-_U25-Pad9_ Net-_U5-Pad1_ 3_and
U25  ? Net-_U25-Pad2_ Net-_U25-Pad3_ Net-_U25-Pad4_ Net-_U25-Pad5_ Net-_U23-Pad2_ GND Net-_U25-Pad8_ Net-_U25-Pad9_ Net-_U25-Pad10_ Net-_U25-Pad11_ Net-_U1-Pad1_ Net-_U25-Pad13_ VDD PORT
U26  Net-_U24-Pad2_ Net-_U25-Pad8_ d_buffer
U24  Net-_U21-Pad3_ Net-_U24-Pad2_ d_inverter
U23  Net-_U20-Pad3_ Net-_U23-Pad2_ d_inverter
M3  Net-_M1-Pad3_ CL Net-_M1-Pad1_ VDD mosfet_p
M1  Net-_M1-Pad1_ CL_BAR Net-_M1-Pad3_ GND mosfet_n
U10  Net-_U10-Pad1_ Net-_M1-Pad1_ dac_bridge_1
U17  Net-_M1-Pad3_ Net-_U12-Pad2_ adc_bridge_1
M6  Net-_M5-Pad3_ CL_BAR Net-_M5-Pad1_ VDD mosfet_p
M5  Net-_M5-Pad1_ CL_BAR Net-_M5-Pad3_ GND mosfet_n
U27  Net-_U13-Pad3_ Net-_M5-Pad1_ dac_bridge_1
U29  Net-_M5-Pad3_ Net-_U19-Pad1_ adc_bridge_1
M7  Net-_M7-Pad1_ CL Net-_M7-Pad3_ VDD mosfet_p
M8  Net-_M7-Pad3_ CL_BAR Net-_M7-Pad1_ GND mosfet_n
U30  Net-_U21-Pad3_ Net-_M7-Pad3_ dac_bridge_1
U28  Net-_M7-Pad1_ Net-_U19-Pad1_ adc_bridge_1
M2  Net-_M2-Pad1_ CL_BAR Net-_M2-Pad3_ VDD mosfet_p
M4  Net-_M2-Pad3_ CL Net-_M2-Pad1_ GND mosfet_n
U22  Net-_U15-Pad3_ Net-_M2-Pad3_ dac_bridge_1
U12  Net-_M2-Pad1_ Net-_U12-Pad2_ adc_bridge_1
U31  Net-_U2-Pad2_ CL dac_bridge_1
U32  Net-_U32-Pad1_ CL_BAR dac_bridge_1
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ d_inverter
U2  Net-_U1-Pad2_ Net-_U2-Pad2_ d_inverter

.end
