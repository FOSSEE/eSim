* C:\Users\chand\esim\FOSSEE\eSim\library\SubcircuitLibrary\SN74LS38\SN74LS38.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/24/25 14:45:38

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
Q3  Net-_Q11-Pad2_ Net-_Q3-Pad2_ Net-_D3-Pad2_ eSim_NPN
Q7  Net-_Q11-Pad2_ Net-_Q3-Pad2_ Net-_D7-Pad2_ eSim_NPN
D3  GND Net-_D3-Pad2_ eSim_Diode
D7  GND Net-_D7-Pad2_ eSim_Diode
Q11  Net-_Q11-Pad1_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_NPN
Q15  Net-_Q15-Pad1_ Net-_Q11-Pad3_ GND eSim_NPN
R9  VCC Net-_Q11-Pad1_ 600
R15  VCC Net-_Q15-Pad1_ 1k
R10  Net-_Q11-Pad3_ GND 400
R3  VCC Net-_Q3-Pad2_ 4k
Q4  Net-_Q12-Pad2_ Net-_Q4-Pad2_ Net-_D4-Pad2_ eSim_NPN
Q8  Net-_Q12-Pad2_ Net-_Q4-Pad2_ Net-_D8-Pad2_ eSim_NPN
D4  GND Net-_D4-Pad2_ eSim_Diode
D8  GND Net-_D8-Pad2_ eSim_Diode
Q12  Net-_Q12-Pad1_ Net-_Q12-Pad2_ Net-_Q12-Pad3_ eSim_NPN
Q16  Net-_Q16-Pad1_ Net-_Q12-Pad3_ GND eSim_NPN
R11  VCC Net-_Q12-Pad1_ 600
R16  VCC Net-_Q16-Pad1_ 1k
R12  Net-_Q12-Pad3_ GND 400
R4  VCC Net-_Q4-Pad2_ 4k
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_D1-Pad2_ eSim_NPN
Q5  Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_D5-Pad2_ eSim_NPN
D1  GND Net-_D1-Pad2_ eSim_Diode
D5  GND Net-_D5-Pad2_ eSim_Diode
Q9  Net-_Q9-Pad1_ Net-_Q1-Pad1_ Net-_Q13-Pad2_ eSim_NPN
Q13  Net-_Q13-Pad1_ Net-_Q13-Pad2_ GND eSim_NPN
R5  VCC Net-_Q9-Pad1_ 600
R13  VCC Net-_Q13-Pad1_ 1k
R6  Net-_Q13-Pad2_ GND 400
R1  VCC Net-_Q1-Pad2_ 4k
Q2  Net-_Q10-Pad2_ Net-_Q2-Pad2_ Net-_D2-Pad2_ eSim_NPN
Q6  Net-_Q10-Pad2_ Net-_Q2-Pad2_ Net-_D6-Pad2_ eSim_NPN
D2  GND Net-_D2-Pad2_ eSim_Diode
D6  GND Net-_D6-Pad2_ eSim_Diode
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
Q14  Net-_Q14-Pad1_ Net-_Q10-Pad3_ GND eSim_NPN
R7  VCC Net-_Q10-Pad1_ 600
R14  VCC Net-_Q14-Pad1_ 600
R8  Net-_Q10-Pad3_ GND 400
R2  VCC Net-_Q2-Pad2_ 4k
U1  Net-_D7-Pad2_ Net-_D3-Pad2_ Net-_Q15-Pad1_ Net-_D8-Pad2_ Net-_D4-Pad2_ Net-_Q16-Pad1_ GND Net-_D5-Pad2_ Net-_D1-Pad2_ Net-_Q13-Pad1_ Net-_D6-Pad2_ Net-_D2-Pad2_ Net-_Q14-Pad1_ VCC PORT

.end
