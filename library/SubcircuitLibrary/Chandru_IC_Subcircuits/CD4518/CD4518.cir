* C:\Users\chand\esim\FOSSEE\eSim\library\SubcircuitLibrary\CD4518\CD4518.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 05/30/25 13:46:23

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U7  Net-_U1-Pad2_ Net-_U4-Pad2_ Net-_U34-Pad1_ d_nand
U8  Net-_U34-Pad1_ Net-_U16-Pad1_ d_inverter
U13  Net-_U13-Pad1_ Net-_U13-Pad2_ Net-_U13-Pad3_ d_and
U30  Net-_U27-Pad2_ Net-_U28-Pad2_ Net-_U30-Pad3_ d_and
U27  Net-_U25-Pad2_ Net-_U27-Pad2_ d_inverter
U28  Net-_U18-Pad2_ Net-_U28-Pad2_ d_inverter
U22  Net-_U22-Pad1_ Net-_U22-Pad2_ Net-_U22-Pad3_ d_and
U23  Net-_U23-Pad1_ Net-_U23-Pad2_ Net-_U22-Pad1_ d_and
U26  Net-_U18-Pad2_ Net-_U23-Pad1_ d_inverter
U24  Net-_U10-Pad1_ Net-_U23-Pad2_ d_inverter
U38  Net-_U36-Pad3_ Net-_U38-Pad2_ Net-_U38-Pad3_ d_and
U36  Net-_U34-Pad2_ Net-_U36-Pad2_ Net-_U36-Pad3_ d_and
U34  Net-_U34-Pad1_ Net-_U34-Pad2_ d_inverter
U37  Net-_U10-Pad1_ Net-_U36-Pad2_ d_inverter
U39  Net-_U30-Pad3_ Net-_U17-Pad1_ Net-_U39-Pad3_ d_nor
U42  Net-_U41-Pad2_ Net-_U17-Pad1_ d_buffer
U41  Net-_U29-Pad2_ Net-_U41-Pad2_ d_inverter
U6  Net-_U5-Pad2_ Net-_U18-Pad3_ d_buffer
U5  Net-_U3-Pad2_ Net-_U5-Pad2_ d_inverter
U3  Net-_U1-Pad3_ Net-_U3-Pad2_ d_inverter
U10  Net-_U10-Pad1_ Net-_U1-Pad8_ d_buffer
U11  Net-_U11-Pad1_ Net-_U10-Pad1_ d_inverter
U12  Net-_U12-Pad1_ Net-_U11-Pad1_ d_inverter
U19  Net-_U19-Pad1_ Net-_U1-Pad7_ d_buffer
U20  Net-_U20-Pad1_ Net-_U19-Pad1_ d_inverter
U21  Net-_U18-Pad4_ Net-_U20-Pad1_ d_inverter
U31  Net-_U31-Pad1_ Net-_U1-Pad6_ d_buffer
U32  Net-_U32-Pad1_ Net-_U31-Pad1_ d_inverter
U33  Net-_U25-Pad4_ Net-_U32-Pad1_ d_inverter
U43  Net-_U43-Pad1_ Net-_U1-Pad5_ d_buffer
U44  Net-_U44-Pad1_ Net-_U43-Pad1_ d_inverter
U45  Net-_U29-Pad4_ Net-_U44-Pad1_ d_inverter
U14  Net-_U14-Pad1_ Net-_U14-Pad2_ Net-_U13-Pad1_ d_and
U17  Net-_U17-Pad1_ Net-_U14-Pad1_ d_inverter
U15  Net-_U10-Pad1_ Net-_U14-Pad2_ d_inverter
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ ? Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ PORT
U4  Net-_U2-Pad2_ Net-_U4-Pad2_ d_buffer
U2  Net-_U1-Pad1_ Net-_U2-Pad2_ d_inverter
U46  Net-_U34-Pad1_ Net-_U13-Pad2_ d_inverter
U47  Net-_U34-Pad1_ Net-_U22-Pad2_ d_inverter
U48  Net-_U39-Pad3_ Net-_U38-Pad2_ d_inverter
U16  Net-_U16-Pad1_ Net-_U16-Pad2_ d_buffer
U9  Net-_U35-Pad2_ Net-_U9-Pad2_ Net-_U18-Pad3_ Net-_U12-Pad1_ Net-_U9-Pad2_ d_flip_flop
U18  Net-_U18-Pad1_ Net-_U18-Pad2_ Net-_U18-Pad3_ Net-_U18-Pad4_ Net-_U18-Pad2_ d_flip_flop
U25  Net-_U25-Pad1_ Net-_U25-Pad2_ Net-_U18-Pad3_ Net-_U25-Pad4_ Net-_U25-Pad2_ d_flip_flop
U29  Net-_U29-Pad1_ Net-_U29-Pad2_ Net-_U18-Pad3_ Net-_U29-Pad4_ Net-_U29-Pad2_ d_flip_flop
U35  Net-_U16-Pad2_ Net-_U35-Pad2_ d_inverter
U40  Net-_U13-Pad3_ Net-_U18-Pad1_ d_inverter
U49  Net-_U22-Pad3_ Net-_U25-Pad1_ d_inverter
U50  Net-_U38-Pad3_ Net-_U29-Pad1_ d_inverter

.end
