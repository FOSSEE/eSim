* C:\FOSSEE\eSim\library\SubcircuitLibrary\MC14560B\MC14560B.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 07/04/25 23:36:10

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U3  Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U10-Pad1_ d_nand
U9  Net-_U1-Pad5_ Net-_U10-Pad1_ Net-_U17-Pad1_ d_and
U10  Net-_U10-Pad1_ Net-_U1-Pad6_ Net-_U10-Pad3_ d_and
U17  Net-_U17-Pad1_ Net-_U10-Pad3_ Net-_U17-Pad3_ d_nor
U2  Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U2-Pad3_ d_nand
U7  Net-_U1-Pad3_ Net-_U2-Pad3_ Net-_U16-Pad1_ d_and
U8  Net-_U2-Pad3_ Net-_U1-Pad4_ Net-_U16-Pad2_ d_and
U16  Net-_U16-Pad1_ Net-_U16-Pad2_ Net-_U16-Pad3_ d_nor
U70  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U14-Pad1_ d_nand
U5  Net-_U1-Pad1_ Net-_U14-Pad1_ Net-_U15-Pad1_ d_and
U6  Net-_U14-Pad1_ Net-_U1-Pad2_ Net-_U15-Pad2_ d_and
U15  Net-_U15-Pad1_ Net-_U15-Pad2_ Net-_U15-Pad3_ d_nor
U4  Net-_U1-Pad15_ Net-_U1-Pad14_ Net-_U11-Pad2_ d_nand
U11  Net-_U1-Pad15_ Net-_U11-Pad2_ Net-_U11-Pad3_ d_and
U12  Net-_U11-Pad2_ Net-_U1-Pad14_ Net-_U12-Pad3_ d_and
U18  Net-_U11-Pad3_ Net-_U12-Pad3_ Net-_U18-Pad3_ d_nor
U13  Net-_U11-Pad2_ Net-_U13-Pad2_ d_inverter
U14  Net-_U14-Pad1_ Net-_U14-Pad2_ d_inverter
U26  Net-_U1-Pad7_ Net-_U18-Pad3_ Net-_U26-Pad3_ d_nand
U29  Net-_U1-Pad7_ Net-_U26-Pad3_ Net-_U29-Pad3_ d_and
U30  Net-_U26-Pad3_ Net-_U18-Pad3_ Net-_U30-Pad3_ d_and
U36  Net-_U29-Pad3_ Net-_U30-Pad3_ Net-_U1-Pad13_ d_nor
U20  Net-_U18-Pad3_ Net-_U20-Pad2_ d_inverter
U19  Net-_U15-Pad3_ Net-_U19-Pad2_ d_inverter
U21  Net-_U16-Pad3_ Net-_U21-Pad2_ d_inverter
U27  Net-_U1-Pad7_ Net-_U20-Pad2_ Net-_U27-Pad3_ d_and
U25  Net-_U13-Pad2_ Net-_U25-Pad2_ d_inverter
U31  Net-_U27-Pad3_ Net-_U25-Pad2_ Net-_U31-Pad3_ d_nor
U34  Net-_U31-Pad3_ Net-_U19-Pad2_ Net-_U34-Pad3_ d_xor
U40  Net-_U34-Pad3_ Net-_U40-Pad2_ d_inverter
X3  Net-_U1-Pad7_ Net-_U20-Pad2_ Net-_U19-Pad2_ Net-_U32-Pad1_ 3_and
U23  Net-_U13-Pad2_ Net-_U19-Pad2_ Net-_U23-Pad3_ d_and
U24  Net-_U14-Pad2_ Net-_U24-Pad2_ d_inverter
U32  Net-_U32-Pad1_ Net-_U23-Pad3_ Net-_U32-Pad3_ d_nor
U37  Net-_U32-Pad3_ Net-_U24-Pad2_ Net-_U37-Pad3_ d_nor
U41  Net-_U37-Pad3_ Net-_U21-Pad2_ Net-_U41-Pad3_ d_xor
X1  Net-_U13-Pad2_ Net-_U19-Pad2_ Net-_U21-Pad2_ Net-_U28-Pad2_ 3_and
U22  Net-_U14-Pad2_ Net-_U21-Pad2_ Net-_U22-Pad3_ d_and
U28  Net-_U28-Pad1_ Net-_U28-Pad2_ Net-_U28-Pad3_ d_nor
U33  Net-_U28-Pad3_ Net-_U22-Pad3_ Net-_U33-Pad3_ d_nor
X2  Net-_U1-Pad7_ Net-_U20-Pad2_ Net-_U19-Pad2_ Net-_U21-Pad2_ Net-_U28-Pad1_ 4_and
X5  Net-_U2-Pad3_ Net-_U33-Pad3_ Net-_U38-Pad3_ Net-_U44-Pad1_ 3_and
U35  Net-_U33-Pad3_ Net-_U2-Pad3_ Net-_U35-Pad3_ d_nand
U38  Net-_U35-Pad3_ Net-_U38-Pad2_ Net-_U38-Pad3_ d_nand
X4  Net-_U33-Pad3_ Net-_U2-Pad3_ Net-_U10-Pad1_ Net-_U43-Pad1_ 3_and
U39  Net-_U38-Pad2_ Net-_U10-Pad1_ Net-_U39-Pad3_ d_and
U43  Net-_U43-Pad1_ Net-_U39-Pad3_ Net-_U43-Pad3_ d_nor
U42  Net-_U38-Pad3_ Net-_U17-Pad3_ Net-_U42-Pad3_ d_and
U44  Net-_U44-Pad1_ Net-_U42-Pad3_ Net-_U44-Pad3_ d_nor
U45  Net-_U44-Pad3_ Net-_U45-Pad2_ d_inverter
U46  Net-_U43-Pad3_ Net-_U46-Pad2_ d_inverter
X8  Net-_U34-Pad3_ Net-_U44-Pad3_ Net-_U46-Pad2_ Net-_U57-Pad1_ 3_and
U49  Net-_U40-Pad2_ Net-_U45-Pad2_ Net-_U49-Pad3_ d_and
U50  Net-_U41-Pad3_ Net-_U45-Pad2_ Net-_U50-Pad3_ d_and
U51  Net-_U40-Pad2_ Net-_U43-Pad3_ Net-_U51-Pad3_ d_and
U57  Net-_U57-Pad1_ Net-_U49-Pad3_ Net-_U57-Pad3_ d_nor
U58  Net-_U50-Pad3_ Net-_U51-Pad3_ Net-_U58-Pad3_ d_nor
U61  Net-_U57-Pad3_ Net-_U58-Pad3_ Net-_U1-Pad12_ d_nor
U47  Net-_U46-Pad2_ Net-_U44-Pad3_ Net-_U47-Pad3_ d_and
X7  Net-_U34-Pad3_ Net-_U41-Pad3_ Net-_U46-Pad2_ Net-_U55-Pad1_ 3_and
U55  Net-_U55-Pad1_ Net-_U47-Pad3_ Net-_U1-Pad9_ d_nor
U48  Net-_U40-Pad2_ Net-_U43-Pad3_ Net-_U48-Pad3_ d_and
X6  Net-_U34-Pad3_ Net-_U41-Pad3_ Net-_U45-Pad2_ Net-_U56-Pad1_ 3_and
U56  Net-_U56-Pad1_ Net-_U48-Pad3_ Net-_U56-Pad3_ d_nor
U60  Net-_U56-Pad3_ Net-_U1-Pad10_ d_inverter
U53  Net-_U34-Pad3_ Net-_U45-Pad2_ Net-_U53-Pad3_ d_and
U54  Net-_U40-Pad2_ Net-_U43-Pad3_ Net-_U54-Pad3_ d_and
U52  Net-_U41-Pad3_ Net-_U46-Pad2_ Net-_U52-Pad3_ d_and
U59  Net-_U52-Pad3_ Net-_U53-Pad3_ Net-_U59-Pad3_ d_nor
U62  Net-_U59-Pad3_ Net-_U54-Pad3_ Net-_U1-Pad11_ d_nor
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ PORT

.end
