* E:\ESIM\FOSSEE\eSim\library\SubcircuitLibrary\LTC6603\LTC6603.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 05/28/25 20:25:04

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
X1  ? Net-_C1-Pad1_ Net-_C3-Pad1_ Net-_U1-Pad8_ ? Net-_R7-Pad2_ Net-_U1-Pad7_ ? lm_741
X3  ? Net-_C6-Pad1_ Net-_C10-Pad1_ Net-_U1-Pad8_ ? Net-_C8-Pad1_ Net-_U1-Pad7_ ? lm_741
X5  ? Net-_C12-Pad1_ Net-_C13-Pad1_ Net-_U1-Pad8_ ? Net-_C14-Pad1_ Net-_U1-Pad7_ ? lm_741
X2  ? Net-_C2-Pad1_ Net-_C4-Pad1_ Net-_U1-Pad8_ ? Net-_C5-Pad1_ Net-_U1-Pad7_ ? lm_741
X4  ? Net-_C7-Pad1_ Net-_C9-Pad1_ Net-_U1-Pad8_ ? Net-_C11-Pad1_ Net-_U1-Pad7_ ? lm_741
R2  Net-_R2-Pad1_ Net-_C3-Pad1_ 1k
R9  Net-_R7-Pad2_ Net-_C8-Pad2_ 1k
R11  Net-_C8-Pad2_ Net-_C10-Pad1_ 1k
R16  Net-_C8-Pad1_ Net-_C14-Pad2_ 1k
R17  Net-_C14-Pad2_ Net-_C13-Pad1_ 1k
R1  Net-_C14-Pad1_ Net-_C5-Pad2_ 1k
R3  Net-_C5-Pad2_ Net-_C4-Pad1_ 1k
R8  Net-_C5-Pad1_ Net-_C11-Pad2_ 1k
R10  Net-_C11-Pad2_ Net-_C9-Pad1_ 1k
R7  Net-_C1-Pad1_ Net-_R7-Pad2_ 10k
R5  Net-_C1-Pad1_ GND 10k
R14  Net-_C6-Pad1_ Net-_C8-Pad1_ 16.53k
R12  Net-_C6-Pad1_ GND 10k
R19  Net-_C12-Pad1_ Net-_C14-Pad1_ 10k
R18  Net-_C12-Pad1_ GND 10k
R6  Net-_C2-Pad1_ Net-_C5-Pad1_ 4.68k
R4  Net-_C2-Pad1_ GND 10k
R15  Net-_C7-Pad1_ Net-_C11-Pad1_ 8.79k
R13  Net-_C7-Pad1_ GND 10k
C3  Net-_C3-Pad1_ GND 0.01u
C10  Net-_C10-Pad1_ GND 0.01u
C13  Net-_C13-Pad1_ GND 0.01u
C4  Net-_C4-Pad1_ GND 0.01u
C9  Net-_C9-Pad1_ GND 0.01u
C8  Net-_C8-Pad1_ Net-_C8-Pad2_ 0.01u
C14  Net-_C14-Pad1_ Net-_C14-Pad2_ 0.01u
C5  Net-_C5-Pad1_ Net-_C5-Pad2_ 0.01u
C11  Net-_C11-Pad1_ Net-_C11-Pad2_ 0.01u
C1  Net-_C1-Pad1_ GND 0.0009u
C6  Net-_C6-Pad1_ GND 0.004u
C12  Net-_C12-Pad1_ GND 0.006u
C2  Net-_C2-Pad1_ GND 0.008u
C7  Net-_C7-Pad1_ GND 0.0099u
X6  ? Net-_C15-Pad1_ Net-_C17-Pad1_ Net-_U1-Pad4_ ? Net-_R26-Pad2_ Net-_U1-Pad3_ ? lm_741
X8  ? Net-_C20-Pad1_ Net-_C24-Pad1_ Net-_U1-Pad4_ ? Net-_C22-Pad1_ Net-_U1-Pad3_ ? lm_741
X10  ? Net-_C26-Pad1_ Net-_C27-Pad1_ Net-_U1-Pad4_ ? Net-_C28-Pad1_ Net-_U1-Pad3_ ? lm_741
X7  ? Net-_C16-Pad1_ Net-_C18-Pad1_ Net-_U1-Pad4_ ? Net-_C19-Pad1_ Net-_U1-Pad3_ ? lm_741
X9  ? Net-_C21-Pad1_ Net-_C23-Pad1_ Net-_U1-Pad4_ ? Net-_C25-Pad1_ Net-_U1-Pad3_ ? lm_741
R21  Net-_R21-Pad1_ Net-_C17-Pad1_ 1k
R28  Net-_R26-Pad2_ Net-_C22-Pad2_ 1k
R30  Net-_C22-Pad2_ Net-_C24-Pad1_ 1k
R35  Net-_C22-Pad1_ Net-_C28-Pad2_ 1k
R36  Net-_C28-Pad2_ Net-_C27-Pad1_ 1k
R20  Net-_C28-Pad1_ Net-_C19-Pad2_ 1k
R22  Net-_C19-Pad2_ Net-_C18-Pad1_ 1k
R27  Net-_C19-Pad1_ Net-_C25-Pad2_ 1k
R29  Net-_C25-Pad2_ Net-_C23-Pad1_ 1k
R26  Net-_C15-Pad1_ Net-_R26-Pad2_ 10k
R24  Net-_C15-Pad1_ GND 10k
R33  Net-_C20-Pad1_ Net-_C22-Pad1_ 16.53k
R31  Net-_C20-Pad1_ GND 10k
R38  Net-_C26-Pad1_ Net-_C28-Pad1_ 10k
R37  Net-_C26-Pad1_ GND 10k
R25  Net-_C16-Pad1_ Net-_C19-Pad1_ 4.68k
R23  Net-_C16-Pad1_ GND 10k
R34  Net-_C21-Pad1_ Net-_C25-Pad1_ 8.79k
R32  Net-_C21-Pad1_ GND 10k
C17  Net-_C17-Pad1_ GND 0.01u
C24  Net-_C24-Pad1_ GND 0.01u
C27  Net-_C27-Pad1_ GND 0.01u
C18  Net-_C18-Pad1_ GND 0.01u
C23  Net-_C23-Pad1_ GND 0.01u
C22  Net-_C22-Pad1_ Net-_C22-Pad2_ 0.01u
C28  Net-_C28-Pad1_ Net-_C28-Pad2_ 0.01u
C19  Net-_C19-Pad1_ Net-_C19-Pad2_ 0.01u
C25  Net-_C25-Pad1_ Net-_C25-Pad2_ 0.01u
C15  Net-_C15-Pad1_ GND 0.0009u
C20  Net-_C20-Pad1_ GND 0.004u
C26  Net-_C26-Pad1_ GND 0.006u
C16  Net-_C16-Pad1_ GND 0.008u
C21  Net-_C21-Pad1_ GND 0.0099u
U1  Net-_R21-Pad1_ GND Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_R2-Pad1_ GND Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_C25-Pad1_ GND Net-_C11-Pad1_ GND PORT

.end
