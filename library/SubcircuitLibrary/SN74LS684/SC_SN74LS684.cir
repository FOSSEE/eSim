* C:\FOSSEE2\eSim\library\SubcircuitLibrary\SC_SN74LS684\SC_SN74LS684.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/21/25 20:23:42

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U10  Net-_U1-Pad17_ Net-_U10-Pad2_ d_inverter
U12  Net-_U1-Pad15_ Net-_U12-Pad2_ d_inverter
U13  Net-_U1-Pad16_ Net-_U13-Pad2_ d_inverter
U15  Net-_U1-Pad14_ Net-_U15-Pad2_ d_inverter
U16  Net-_U1-Pad11_ Net-_U16-Pad2_ d_inverter
U17  Net-_U1-Pad12_ Net-_U17-Pad2_ d_inverter
U6  Net-_U1-Pad8_ Net-_U22-Pad1_ d_inverter
U7  Net-_U1-Pad9_ Net-_U22-Pad2_ d_inverter
U8  Net-_U1-Pad6_ Net-_U24-Pad1_ d_inverter
U9  Net-_U1-Pad7_ Net-_U24-Pad2_ d_inverter
U4  Net-_U1-Pad4_ Net-_U25-Pad1_ d_inverter
U5  Net-_U1-Pad5_ Net-_U25-Pad2_ d_inverter
U11  Net-_U1-Pad18_ Net-_U11-Pad2_ d_inverter
U14  Net-_U1-Pad13_ Net-_U14-Pad2_ d_inverter
U2  Net-_U1-Pad2_ Net-_U2-Pad2_ d_inverter
U3  Net-_U1-Pad3_ Net-_U23-Pad2_ d_inverter
U18  Net-_U10-Pad2_ Net-_U11-Pad2_ Net-_U18-Pad3_ d_xnor
U19  Net-_U12-Pad2_ Net-_U13-Pad2_ Net-_U19-Pad3_ d_xnor
U20  Net-_U14-Pad2_ Net-_U15-Pad2_ Net-_U20-Pad3_ d_xnor
U21  Net-_U16-Pad2_ Net-_U17-Pad2_ Net-_U21-Pad3_ d_xnor
U22  Net-_U22-Pad1_ Net-_U22-Pad2_ Net-_U22-Pad3_ d_xnor
U24  Net-_U24-Pad1_ Net-_U24-Pad2_ Net-_U24-Pad3_ d_xnor
U25  Net-_U25-Pad1_ Net-_U25-Pad2_ Net-_U25-Pad3_ d_xnor
U23  Net-_U2-Pad2_ Net-_U23-Pad2_ Net-_U23-Pad3_ d_xnor
X12  Net-_U18-Pad3_ Net-_U19-Pad3_ Net-_U20-Pad3_ Net-_U21-Pad3_ Net-_U22-Pad3_ Net-_U40-Pad1_ 5_and
X11  Net-_U24-Pad3_ Net-_U25-Pad3_ Net-_U23-Pad3_ Net-_U40-Pad2_ 3_and
X9  Net-_U25-Pad3_ Net-_U24-Pad3_ Net-_U22-Pad3_ Net-_U21-Pad3_ Net-_U20-Pad3_ Net-_U37-Pad1_ 5_and
X8  Net-_U24-Pad3_ Net-_U22-Pad3_ Net-_U21-Pad3_ Net-_U20-Pad3_ Net-_U19-Pad3_ Net-_U39-Pad1_ 5_and
X5  Net-_U18-Pad3_ Net-_U25-Pad1_ Net-_U32-Pad2_ Net-_U39-Pad2_ 3_and
U39  Net-_U39-Pad1_ Net-_U39-Pad2_ Net-_U39-Pad3_ d_and
X7  Net-_U22-Pad3_ Net-_U21-Pad3_ Net-_U20-Pad3_ Net-_U19-Pad3_ Net-_U18-Pad3_ Net-_U36-Pad1_ 5_and
U35  Net-_U24-Pad1_ Net-_U30-Pad2_ Net-_U35-Pad3_ d_and
U36  Net-_U36-Pad1_ Net-_U35-Pad3_ Net-_U36-Pad3_ d_and
X1  Net-_U21-Pad3_ Net-_U20-Pad3_ Net-_U19-Pad3_ Net-_U38-Pad1_ 3_and
X3  Net-_U18-Pad3_ Net-_U22-Pad1_ Net-_U31-Pad2_ Net-_U38-Pad2_ 3_and
U38  Net-_U38-Pad1_ Net-_U38-Pad2_ Net-_U38-Pad3_ d_and
X6  Net-_U20-Pad3_ Net-_U19-Pad3_ Net-_U18-Pad3_ Net-_U16-Pad2_ Net-_U26-Pad2_ Net-_X14-Pad1_ 5_and
X4  Net-_U19-Pad3_ Net-_U18-Pad3_ Net-_U14-Pad2_ Net-_U27-Pad2_ Net-_X14-Pad2_ 4_and
X2  Net-_U18-Pad3_ Net-_U12-Pad2_ Net-_U28-Pad2_ Net-_X14-Pad3_ 3_and
U34  Net-_U10-Pad2_ Net-_U29-Pad2_ Net-_U34-Pad3_ d_and
X10  Net-_U19-Pad3_ Net-_U18-Pad3_ Net-_U2-Pad2_ Net-_U33-Pad2_ Net-_U37-Pad2_ 4_and
U37  Net-_U37-Pad1_ Net-_U37-Pad2_ Net-_U37-Pad3_ d_and
U33  Net-_U23-Pad2_ Net-_U33-Pad2_ d_inverter
U32  Net-_U25-Pad2_ Net-_U32-Pad2_ d_inverter
U30  Net-_U24-Pad2_ Net-_U30-Pad2_ d_inverter
U31  Net-_U22-Pad2_ Net-_U31-Pad2_ d_inverter
U26  Net-_U17-Pad2_ Net-_U26-Pad2_ d_inverter
U27  Net-_U15-Pad2_ Net-_U27-Pad2_ d_inverter
U28  Net-_U13-Pad2_ Net-_U28-Pad2_ d_inverter
U29  Net-_U11-Pad2_ Net-_U29-Pad2_ d_inverter
U40  Net-_U40-Pad1_ Net-_U40-Pad2_ Net-_U1-Pad19_ d_nand
X13  Net-_U37-Pad3_ Net-_U39-Pad3_ Net-_U36-Pad3_ Net-_U38-Pad3_ Net-_U41-Pad1_ 4_OR
X14  Net-_X14-Pad1_ Net-_X14-Pad2_ Net-_X14-Pad3_ Net-_U34-Pad3_ Net-_U41-Pad2_ 4_OR
U41  Net-_U41-Pad1_ Net-_U41-Pad2_ Net-_U1-Pad1_ d_nor
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ ? Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ Net-_U1-Pad16_ Net-_U1-Pad17_ Net-_U1-Pad18_ Net-_U1-Pad19_ ? PORT

.end
