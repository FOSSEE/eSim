.title KiCad schematic
U18 Net-_U18-Pad1_ Net-_U18-Pad2_ Net-_U18-Pad3_ d_and
U19 Net-_U16-Pad2_ Net-_U12-Pad2_ Net-_U19-Pad3_ d_and
U17 Net-_U13-Pad2_ Net-_U17-Pad2_ Net-_U17-Pad3_ d_and
U21 Net-_U13-Pad2_ Net-_U12-Pad2_ Net-_U21-Pad3_ d_and
U22 Net-_U20-Pad1_ Net-_U18-Pad2_ Net-_U22-Pad3_ d_and
U20 Net-_U20-Pad1_ Net-_U18-Pad2_ Net-_U20-Pad3_ d_and
U2 Net-_U2-Pad1_ Net-_U2-Pad2_ Net-_U2-Pad3_ Net-_U2-Pad4_ Net-_U2-Pad5_ Net-_U2-Pad6_ Net-_U2-Pad7_ Net-_U2-Pad8_ Net-_U2-Pad9_ Net-_U2-Pad10_ Net-_U2-Pad12_ Net-_U2-Pad13_ Net-_U12-Pad1_ Net-_U16-Pad1_ PORT
U51 Net-_U41-Pad3_ Net-_U2-Pad5_ d_inverter
U41 Net-_U25-Pad3_ Net-_U26-Pad3_ Net-_U41-Pad3_ d_and
U23 Net-_U16-Pad2_ Net-_U17-Pad2_ Net-_U23-Pad3_ d_and
U24 Net-_U20-Pad1_ Net-_U18-Pad2_ Net-_U24-Pad3_ d_and
U25 Net-_U13-Pad2_ Net-_U17-Pad2_ Net-_U25-Pad3_ d_and
U26 Net-_U20-Pad1_ Net-_U18-Pad2_ Net-_U26-Pad3_ d_and
U40 Net-_U23-Pad3_ Net-_U24-Pad3_ Net-_U40-Pad3_ d_and
U50 Net-_U40-Pad3_ Net-_U2-Pad4_ d_inverter
U39 Net-_U21-Pad3_ Net-_U22-Pad3_ Net-_U39-Pad3_ d_and
U49 Net-_U39-Pad3_ Net-_U2-Pad3_ d_inverter
U37 Net-_U17-Pad3_ Net-_U18-Pad3_ Net-_U37-Pad3_ d_and
U38 Net-_U19-Pad3_ Net-_U20-Pad3_ Net-_U38-Pad3_ d_and
U47 Net-_U37-Pad3_ Net-_U2-Pad1_ d_inverter
U48 Net-_U38-Pad3_ Net-_U2-Pad2_ d_inverter
U5 Net-_U5-Pad1_ Net-_U20-Pad1_ d_buffer
U78 Net-_U18-Pad1_ Net-_U5-Pad1_ d_inverter
U1 Net-_U1-Pad1_ Net-_U1-Pad2_ d_buffer
U77 Net-_U18-Pad2_ Net-_U1-Pad1_ d_inverter
U42 Net-_U27-Pad3_ Net-_U28-Pad3_ Net-_U42-Pad3_ d_and
U52 Net-_U42-Pad3_ Net-_U2-Pad6_ d_inverter
U8 Net-_U2-Pad13_ Net-_U18-Pad1_ d_inverter
U4 Net-_U2-Pad12_ Net-_U18-Pad2_ d_inverter
U12 Net-_U12-Pad1_ Net-_U12-Pad2_ d_inverter
U16 Net-_U16-Pad1_ Net-_U16-Pad2_ d_inverter
U9 Net-_U79-Pad2_ Net-_U17-Pad2_ d_buffer
U13 Net-_U13-Pad1_ Net-_U13-Pad2_ d_buffer
U79 Net-_U12-Pad2_ Net-_U79-Pad2_ d_inverter
U80 Net-_U16-Pad2_ Net-_U13-Pad1_ d_inverter
U36 Net-_U20-Pad1_ Net-_U1-Pad2_ Net-_U36-Pad3_ d_and
U28 Net-_U18-Pad1_ Net-_U1-Pad2_ Net-_U28-Pad3_ d_and
U27 Net-_U16-Pad2_ Net-_U12-Pad2_ Net-_U27-Pad3_ d_and
U29 Net-_U13-Pad2_ Net-_U12-Pad2_ Net-_U29-Pad3_ d_and
U31 Net-_U16-Pad2_ Net-_U17-Pad2_ Net-_U31-Pad3_ d_and
U30 Net-_U18-Pad1_ Net-_U1-Pad2_ Net-_U30-Pad3_ d_and
U43 Net-_U29-Pad3_ Net-_U30-Pad3_ Net-_U43-Pad3_ d_and
U54 Net-_U44-Pad3_ Net-_U2-Pad8_ d_inverter
U53 Net-_U43-Pad3_ Net-_U2-Pad7_ d_inverter
U44 Net-_U31-Pad3_ Net-_U32-Pad3_ Net-_U44-Pad3_ d_and
U46 Net-_U35-Pad3_ Net-_U36-Pad3_ Net-_U46-Pad3_ d_and
U45 Net-_U33-Pad3_ Net-_U34-Pad3_ Net-_U45-Pad3_ d_and
U35 Net-_U16-Pad2_ Net-_U12-Pad2_ Net-_U35-Pad3_ d_and
U34 Net-_U18-Pad1_ Net-_U1-Pad2_ Net-_U34-Pad3_ d_and
U32 Net-_U18-Pad1_ Net-_U1-Pad2_ Net-_U32-Pad3_ d_and
U33 Net-_U13-Pad2_ Net-_U17-Pad2_ Net-_U33-Pad3_ d_and
U56 Net-_U46-Pad3_ Net-_U2-Pad10_ d_inverter
U55 Net-_U45-Pad3_ Net-_U2-Pad9_ d_inverter
.end
