.title KiCad schematic
Q5 Net-_D7-Pad1_ Net-_D4-Pad1_ Net-_D1-Pad2_ eSim_NPN
U1 Net-_D7-Pad1_ Net-_Q3-Pad2_ Net-_Q1-Pad2_ Net-_D1-Pad2_ Net-_D1-Pad1_ Net-_Q15-Pad3_ Net-_D2-Pad1_ Net-_D9-Pad2_ PORT
Q2 Net-_Q1-Pad3_ Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_NPN
D4 Net-_D4-Pad1_ Net-_D1-Pad2_ eSim_Diode
D1 Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
D3 Net-_D2-Pad1_ Net-_D3-Pad2_ eSim_Diode
D2 Net-_D2-Pad1_ Net-_D2-Pad2_ eSim_Diode
Q1 Net-_D2-Pad2_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
Q3 Net-_D3-Pad2_ Net-_Q3-Pad2_ Net-_Q1-Pad3_ eSim_NPN
D5 Net-_D5-Pad1_ Net-_D4-Pad1_ eSim_Diode
Q4 Net-_D5-Pad1_ Net-_D2-Pad2_ Net-_D2-Pad1_ eSim_PNP
Q6 Net-_D7-Pad1_ Net-_D3-Pad2_ Net-_D2-Pad1_ eSim_PNP
Q7 Net-_D6-Pad2_ Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_NPN
D6 Net-_D2-Pad1_ Net-_D6-Pad2_ eSim_Diode
Q17 Net-_Q15-Pad3_ Net-_Q16-Pad1_ Net-_Q12-Pad2_ eSim_PNP
R1 Net-_Q12-Pad2_ Net-_D2-Pad1_ 50
Q16 Net-_Q16-Pad1_ Net-_Q10-Pad1_ Net-_Q15-Pad3_ eSim_NPN
Q12 Net-_D6-Pad2_ Net-_Q12-Pad2_ Net-_D2-Pad1_ eSim_PNP
Q10 Net-_Q10-Pad1_ Net-_D6-Pad2_ Net-_D2-Pad1_ eSim_PNP
Q11 Net-_Q11-Pad1_ Net-_D9-Pad1_ Net-_Q10-Pad1_ eSim_PNP
Q15 Net-_Q15-Pad1_ Net-_D9-Pad2_ Net-_Q15-Pad3_ eSim_PNP
Q14 Net-_D7-Pad1_ Net-_Q14-Pad2_ Net-_D1-Pad2_ eSim_NPN
Q13 Net-_Q10-Pad1_ Net-_Q11-Pad1_ Net-_D9-Pad2_ eSim_NPN
Q18 Net-_Q15-Pad3_ Net-_Q15-Pad1_ Net-_Q14-Pad2_ eSim_NPN
R2 Net-_D1-Pad2_ Net-_Q14-Pad2_ 50
D9 Net-_D9-Pad1_ Net-_D9-Pad2_ eSim_Diode
D7 Net-_D7-Pad1_ Net-_D7-Pad2_ eSim_Diode
Q9 Net-_D9-Pad2_ Net-_D7-Pad2_ Net-_D1-Pad2_ eSim_NPN
D8 Net-_D7-Pad2_ Net-_D1-Pad2_ eSim_Diode
Q8 Net-_D2-Pad1_ Net-_D7-Pad1_ Net-_D7-Pad2_ eSim_NPN
.end
