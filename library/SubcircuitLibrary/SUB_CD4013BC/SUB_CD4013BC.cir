* C:\FOSSEE\eSim\library\SubcircuitLibrary\SUB_CD4013BC\SUB_CD4013BC.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/05/25 12:38:01

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
M9  VDD Net-_M23-Pad2_ Net-_M10-Pad1_ VDD eSim_MOS_P
M8  Net-_M10-Pad3_ Net-_M1-Pad3_ VSS VSS eSim_MOS_N
M10  Net-_M10-Pad1_ Net-_M1-Pad3_ Net-_M10-Pad3_ VDD eSim_MOS_P
M7  Net-_M10-Pad3_ Net-_M23-Pad2_ VSS VSS eSim_MOS_N
M1  Net-_M1-Pad1_ Net-_M1-Pad2_ Net-_M1-Pad3_ VSS eSim_MOS_N
M2  Net-_M1-Pad3_ VDD Net-_M1-Pad1_ VDD eSim_MOS_P
M15  VDD Net-_M11-Pad2_ Net-_M15-Pad3_ VDD eSim_MOS_P
M16  Net-_M15-Pad3_ Net-_M10-Pad3_ Net-_M11-Pad1_ VDD eSim_MOS_P
M14  Net-_M11-Pad1_ Net-_M10-Pad3_ VSS VSS eSim_MOS_N
M11  Net-_M11-Pad1_ Net-_M11-Pad2_ VSS VSS eSim_MOS_N
M17  Net-_M10-Pad3_ VDD Net-_M17-Pad3_ VSS eSim_MOS_N
M18  Net-_M17-Pad3_ Net-_M1-Pad2_ Net-_M10-Pad3_ VDD eSim_MOS_P
M21  VDD Net-_M11-Pad2_ Net-_M21-Pad3_ VDD eSim_MOS_P
M22  Net-_M21-Pad3_ Net-_M17-Pad3_ Net-_M19-Pad1_ VDD eSim_MOS_P
M20  Net-_M19-Pad1_ Net-_M17-Pad3_ VSS VSS eSim_MOS_N
M19  Net-_M19-Pad1_ Net-_M11-Pad2_ VSS VSS eSim_MOS_N
M28  VDD Net-_M23-Pad2_ Net-_M28-Pad3_ VDD eSim_MOS_P
M29  Net-_M28-Pad3_ Net-_M19-Pad1_ Net-_M23-Pad1_ VDD eSim_MOS_P
M25  Net-_M23-Pad1_ Net-_M19-Pad1_ VSS VSS eSim_MOS_N
M23  Net-_M23-Pad1_ Net-_M23-Pad2_ VSS VSS eSim_MOS_N
M26  Net-_M17-Pad3_ Net-_M1-Pad2_ Net-_M23-Pad1_ VSS eSim_MOS_N
M30  Net-_M23-Pad1_ VDD Net-_M17-Pad3_ VDD eSim_MOS_P
M32  VDD Net-_M19-Pad1_ Net-_M31-Pad1_ VDD eSim_MOS_P
M31  Net-_M31-Pad1_ Net-_M19-Pad1_ VSS VSS eSim_MOS_N
M27  VDD Net-_M17-Pad3_ Net-_M24-Pad1_ VDD eSim_MOS_P
M24  Net-_M24-Pad1_ Net-_M17-Pad3_ VSS VSS eSim_MOS_N
M12  Net-_M1-Pad3_ VDD Net-_M11-Pad1_ VSS eSim_MOS_N
M13  Net-_M11-Pad1_ Net-_M1-Pad2_ Net-_M1-Pad3_ VDD eSim_MOS_P
M4  VDD Net-_M3-Pad2_ Net-_M1-Pad2_ VDD eSim_MOS_P
M3  Net-_M1-Pad2_ Net-_M3-Pad2_ VSS VSS eSim_MOS_N
M6  VDD Net-_M1-Pad2_ VDD VDD eSim_MOS_P
M5  VDD Net-_M1-Pad2_ VSS VSS eSim_MOS_N
M34  Net-_M33-Pad3_ Net-_M24-Pad1_ VSS VSS eSim_MOS_N
M33  VDD Net-_M24-Pad1_ Net-_M33-Pad3_ VDD eSim_MOS_P
U1  VDD VSS Net-_M23-Pad2_ Net-_M11-Pad2_ Net-_M3-Pad2_ Net-_M1-Pad1_ Net-_M33-Pad3_ Net-_M24-Pad1_ Net-_M41-Pad2_ Net-_M45-Pad2_ Net-_M37-Pad2_ Net-_M35-Pad1_ Net-_M67-Pad1_ Net-_M58-Pad1_ PORT
M43  VDD Net-_M41-Pad2_ Net-_M43-Pad3_ VDD eSim_MOS_P
M42  Net-_M41-Pad1_ Net-_M35-Pad3_ VSS VSS eSim_MOS_N
M44  Net-_M43-Pad3_ Net-_M35-Pad3_ Net-_M41-Pad1_ VDD eSim_MOS_P
M41  Net-_M41-Pad1_ Net-_M41-Pad2_ VSS VSS eSim_MOS_N
M35  Net-_M35-Pad1_ Net-_M35-Pad2_ Net-_M35-Pad3_ VSS eSim_MOS_N
M36  Net-_M35-Pad3_ VDD Net-_M35-Pad1_ VDD eSim_MOS_P
M49  VDD Net-_M45-Pad2_ Net-_M49-Pad3_ VDD eSim_MOS_P
M50  Net-_M49-Pad3_ Net-_M41-Pad1_ Net-_M45-Pad1_ VDD eSim_MOS_P
M48  Net-_M45-Pad1_ Net-_M41-Pad1_ VSS VSS eSim_MOS_N
M45  Net-_M45-Pad1_ Net-_M45-Pad2_ VSS VSS eSim_MOS_N
M51  Net-_M41-Pad1_ VDD Net-_M51-Pad3_ VSS eSim_MOS_N
M52  Net-_M51-Pad3_ Net-_M35-Pad2_ Net-_M41-Pad1_ VDD eSim_MOS_P
M55  VDD Net-_M45-Pad2_ Net-_M55-Pad3_ VDD eSim_MOS_P
M56  Net-_M55-Pad3_ Net-_M51-Pad3_ Net-_M53-Pad1_ VDD eSim_MOS_P
M54  Net-_M53-Pad1_ Net-_M51-Pad3_ VSS VSS eSim_MOS_N
M53  Net-_M53-Pad1_ Net-_M45-Pad2_ VSS VSS eSim_MOS_N
M62  VDD Net-_M41-Pad2_ Net-_M62-Pad3_ VDD eSim_MOS_P
M63  Net-_M62-Pad3_ Net-_M53-Pad1_ Net-_M57-Pad1_ VDD eSim_MOS_P
M59  Net-_M57-Pad1_ Net-_M53-Pad1_ VSS VSS eSim_MOS_N
M57  Net-_M57-Pad1_ Net-_M41-Pad2_ VSS VSS eSim_MOS_N
M60  Net-_M51-Pad3_ Net-_M35-Pad2_ Net-_M57-Pad1_ VSS eSim_MOS_N
M64  Net-_M57-Pad1_ VDD Net-_M51-Pad3_ VDD eSim_MOS_P
M66  VDD Net-_M53-Pad1_ Net-_M65-Pad1_ VDD eSim_MOS_P
M65  Net-_M65-Pad1_ Net-_M53-Pad1_ VSS VSS eSim_MOS_N
M61  VDD Net-_M51-Pad3_ Net-_M58-Pad1_ VDD eSim_MOS_P
M58  Net-_M58-Pad1_ Net-_M51-Pad3_ VSS VSS eSim_MOS_N
M46  Net-_M35-Pad3_ VDD Net-_M45-Pad1_ VSS eSim_MOS_N
M47  Net-_M45-Pad1_ Net-_M35-Pad2_ Net-_M35-Pad3_ VDD eSim_MOS_P
M38  VDD Net-_M37-Pad2_ Net-_M35-Pad2_ VDD eSim_MOS_P
M37  Net-_M35-Pad2_ Net-_M37-Pad2_ VSS VSS eSim_MOS_N
M40  VDD Net-_M35-Pad2_ VDD VDD eSim_MOS_P
M39  VDD Net-_M35-Pad2_ VSS VSS eSim_MOS_N
M67  Net-_M67-Pad1_ Net-_M58-Pad1_ VSS VSS eSim_MOS_N
M68  VDD Net-_M58-Pad1_ Net-_M67-Pad1_ VDD eSim_MOS_P

.end
