* C:\FOSSEE2\eSim\library\SubcircuitLibrary\SC_SN74LS670\SC_SN74LS670.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/13/25 13:57:03

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U18  Net-_U18-Pad1_ Net-_U12-Pad3_ ? ? Net-_U18-Pad5_ ? d_dlatch
U26  Net-_U18-Pad1_ Net-_U22-Pad3_ ? ? Net-_U26-Pad5_ ? d_dlatch
U34  Net-_U18-Pad1_ Net-_U30-Pad3_ ? ? Net-_U34-Pad5_ ? d_dlatch
U42  Net-_U18-Pad1_ Net-_U38-Pad3_ ? ? Net-_U42-Pad5_ ? d_dlatch
U12  Net-_U10-Pad1_ Net-_U10-Pad2_ Net-_U12-Pad3_ d_and
U22  Net-_U10-Pad1_ Net-_U14-Pad2_ Net-_U22-Pad3_ d_and
U30  Net-_U28-Pad1_ Net-_U10-Pad2_ Net-_U30-Pad3_ d_and
U38  Net-_U28-Pad1_ Net-_U14-Pad2_ Net-_U38-Pad3_ d_and
U6  Net-_U1-Pad15_ Net-_U18-Pad1_ d_inverter
X19  Net-_X11-Pad4_ Net-_X12-Pad4_ Net-_X19-Pad3_ Net-_X19-Pad4_ Net-_U51-Pad1_ 4_OR
U51  Net-_U51-Pad1_ Net-_U51-Pad2_ d_inverter
U55  Net-_U51-Pad2_ Net-_U48-Pad2_ Net-_U1-Pad10_ d_and
U19  Net-_U19-Pad1_ Net-_U13-Pad3_ ? ? Net-_U19-Pad5_ ? d_dlatch
U27  Net-_U19-Pad1_ Net-_U23-Pad3_ ? ? Net-_U27-Pad5_ ? d_dlatch
U35  Net-_U19-Pad1_ Net-_U31-Pad3_ ? ? Net-_U35-Pad5_ ? d_dlatch
U43  Net-_U19-Pad1_ Net-_U39-Pad3_ ? ? Net-_U43-Pad5_ ? d_dlatch
U13  Net-_U10-Pad1_ Net-_U10-Pad2_ Net-_U13-Pad3_ d_and
U23  Net-_U10-Pad1_ Net-_U14-Pad2_ Net-_U23-Pad3_ d_and
U31  Net-_U28-Pad1_ Net-_U10-Pad2_ Net-_U31-Pad3_ d_and
U39  Net-_U28-Pad1_ Net-_U14-Pad2_ Net-_U39-Pad3_ d_and
U4  Net-_U1-Pad1_ Net-_U19-Pad1_ d_inverter
X20  Net-_X15-Pad4_ Net-_X16-Pad4_ Net-_X13-Pad4_ Net-_X14-Pad4_ Net-_U52-Pad1_ 4_OR
U52  Net-_U52-Pad1_ Net-_U52-Pad2_ d_inverter
U56  Net-_U52-Pad2_ Net-_U48-Pad2_ Net-_U1-Pad9_ d_and
U17  Net-_U17-Pad1_ Net-_U11-Pad3_ ? ? Net-_U17-Pad5_ ? d_dlatch
U25  Net-_U17-Pad1_ Net-_U21-Pad3_ ? ? Net-_U25-Pad5_ ? d_dlatch
U33  Net-_U17-Pad1_ Net-_U29-Pad3_ ? ? Net-_U33-Pad5_ ? d_dlatch
U41  Net-_U17-Pad1_ Net-_U37-Pad3_ ? ? Net-_U41-Pad5_ ? d_dlatch
U11  Net-_U10-Pad1_ Net-_U10-Pad2_ Net-_U11-Pad3_ d_and
U21  Net-_U10-Pad1_ Net-_U14-Pad2_ Net-_U21-Pad3_ d_and
U29  Net-_U28-Pad1_ Net-_U10-Pad2_ Net-_U29-Pad3_ d_and
U37  Net-_U28-Pad1_ Net-_U14-Pad2_ Net-_U37-Pad3_ d_and
U3  Net-_U1-Pad2_ Net-_U17-Pad1_ d_inverter
X18  Net-_X18-Pad1_ Net-_X10-Pad4_ Net-_X18-Pad3_ Net-_X18-Pad4_ Net-_U50-Pad1_ 4_OR
U50  Net-_U50-Pad1_ Net-_U50-Pad2_ d_inverter
U54  Net-_U50-Pad2_ Net-_U48-Pad2_ Net-_U1-Pad7_ d_and
U16  Net-_U16-Pad1_ Net-_U10-Pad3_ ? ? Net-_U16-Pad5_ ? d_dlatch
U24  Net-_U16-Pad1_ Net-_U20-Pad3_ ? ? Net-_U24-Pad5_ ? d_dlatch
U32  Net-_U16-Pad1_ Net-_U28-Pad3_ ? ? Net-_U32-Pad5_ ? d_dlatch
U40  Net-_U16-Pad1_ Net-_U36-Pad3_ ? ? Net-_U40-Pad5_ ? d_dlatch
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ Net-_U10-Pad3_ d_and
U20  Net-_U10-Pad1_ Net-_U14-Pad2_ Net-_U20-Pad3_ d_and
U28  Net-_U28-Pad1_ Net-_U10-Pad2_ Net-_U28-Pad3_ d_and
U36  Net-_U28-Pad1_ Net-_U14-Pad2_ Net-_U36-Pad3_ d_and
U2  Net-_U1-Pad3_ Net-_U16-Pad1_ d_inverter
X17  Net-_X17-Pad1_ Net-_X17-Pad2_ Net-_X1-Pad4_ Net-_X17-Pad4_ Net-_U49-Pad1_ 4_OR
U49  Net-_U49-Pad1_ Net-_U49-Pad2_ d_inverter
U53  Net-_U49-Pad2_ Net-_U48-Pad2_ Net-_U1-Pad6_ d_and
U5  Net-_U1-Pad12_ Net-_U5-Pad2_ Net-_U28-Pad1_ d_nor
U8  Net-_U7-Pad2_ Net-_U5-Pad2_ Net-_U10-Pad1_ d_and
U7  Net-_U1-Pad12_ Net-_U7-Pad2_ d_inverter
U9  Net-_U1-Pad13_ Net-_U5-Pad2_ d_inverter
U14  Net-_U10-Pad2_ Net-_U14-Pad2_ d_inverter
U15  Net-_U1-Pad14_ Net-_U10-Pad2_ d_inverter
U46  Net-_U46-Pad1_ Net-_U46-Pad2_ Net-_U46-Pad3_ d_nor
U47  Net-_U46-Pad1_ Net-_U1-Pad5_ Net-_U46-Pad2_ d_nor
U48  Net-_U46-Pad1_ Net-_U48-Pad2_ d_inverter
U44  Net-_U44-Pad1_ Net-_U44-Pad2_ d_inverter
U45  Net-_U1-Pad4_ Net-_U44-Pad1_ d_inverter
X6  Net-_U24-Pad5_ Net-_U44-Pad1_ Net-_U46-Pad3_ Net-_X17-Pad2_ 3_and
X1  Net-_U32-Pad5_ Net-_U44-Pad2_ Net-_U46-Pad2_ Net-_X1-Pad4_ 3_and
X2  Net-_U40-Pad5_ Net-_U44-Pad2_ Net-_U46-Pad3_ Net-_X17-Pad4_ 3_and
X5  Net-_U16-Pad5_ Net-_U44-Pad1_ Net-_U46-Pad2_ Net-_X17-Pad1_ 3_and
X9  Net-_U17-Pad5_ Net-_U44-Pad1_ Net-_U46-Pad2_ Net-_X18-Pad1_ 3_and
X10  Net-_U25-Pad5_ Net-_U44-Pad1_ Net-_U46-Pad3_ Net-_X10-Pad4_ 3_and
X3  Net-_U33-Pad5_ Net-_U44-Pad2_ Net-_U46-Pad2_ Net-_X18-Pad3_ 3_and
X4  Net-_U41-Pad5_ Net-_U44-Pad2_ Net-_U46-Pad3_ Net-_X18-Pad4_ 3_and
X15  Net-_U19-Pad5_ Net-_U44-Pad1_ Net-_U46-Pad2_ Net-_X15-Pad4_ 3_and
X16  Net-_U27-Pad5_ Net-_U44-Pad1_ Net-_U46-Pad3_ Net-_X16-Pad4_ 3_and
X13  Net-_U35-Pad5_ Net-_U44-Pad2_ Net-_U46-Pad2_ Net-_X13-Pad4_ 3_and
X14  Net-_U43-Pad5_ Net-_U44-Pad2_ Net-_U46-Pad3_ Net-_X14-Pad4_ 3_and
X11  Net-_U18-Pad5_ Net-_U44-Pad1_ Net-_U46-Pad2_ Net-_X11-Pad4_ 3_and
X12  Net-_U26-Pad5_ Net-_U44-Pad1_ Net-_U46-Pad3_ Net-_X12-Pad4_ 3_and
X7  Net-_U34-Pad5_ Net-_U44-Pad2_ Net-_U46-Pad2_ Net-_X19-Pad3_ 3_and
X8  Net-_U42-Pad5_ Net-_U44-Pad2_ Net-_U46-Pad3_ Net-_X19-Pad4_ 3_and
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ ? Net-_U1-Pad9_ Net-_U1-Pad10_ ? Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ ? PORT

.end
