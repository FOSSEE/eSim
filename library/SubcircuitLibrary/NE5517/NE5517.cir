* C:\FOSSEE\eSim\library\SubcircuitLibrary\NE5517\NE5517.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 07/12/25 12:59:32

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
Q3  Net-_Q2-Pad1_ Net-_D2-Pad2_ Net-_D11-Pad1_ eSim_PNP
Q5  Net-_Q10-Pad2_ Net-_Q2-Pad1_ Net-_D2-Pad2_ eSim_PNP
D2  Net-_D11-Pad1_ Net-_D2-Pad2_ eSim_Diode
Q2  Net-_Q2-Pad1_ Net-_D7-Pad2_ Net-_Q2-Pad3_ eSim_NPN
Q6  Net-_Q6-Pad1_ Net-_D8-Pad2_ Net-_Q2-Pad3_ eSim_NPN
Q4  Net-_Q2-Pad3_ Net-_Q1-Pad1_ Net-_D1-Pad1_ eSim_NPN
Q1  Net-_Q1-Pad1_ Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_NPN
D1  Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
Q7  Net-_Q6-Pad1_ Net-_D3-Pad2_ Net-_D11-Pad1_ eSim_PNP
Q9  Net-_Q10-Pad1_ Net-_Q6-Pad1_ Net-_D3-Pad2_ eSim_PNP
D3  Net-_D11-Pad1_ Net-_D3-Pad2_ eSim_Diode
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_D4-Pad1_ eSim_NPN
Q8  Net-_Q10-Pad2_ Net-_D4-Pad1_ Net-_D1-Pad2_ eSim_NPN
D4  Net-_D4-Pad1_ Net-_D1-Pad2_ eSim_Diode
Q11  Net-_Q11-Pad1_ Net-_Q11-Pad1_ Net-_D11-Pad1_ eSim_PNP
Q13  Net-_D5-Pad1_ Net-_Q11-Pad1_ Net-_D11-Pad1_ eSim_PNP
Q12  Net-_Q11-Pad1_ Net-_D1-Pad1_ Net-_Q12-Pad3_ eSim_NPN
Q14  Net-_Q11-Pad1_ Net-_D5-Pad1_ Net-_Q12-Pad3_ eSim_NPN
R6  Net-_Q12-Pad3_ Net-_D1-Pad2_ 1k
D5  Net-_D5-Pad1_ Net-_D5-Pad2_ eSim_Diode
D6  Net-_D5-Pad2_ Net-_D1-Pad2_ eSim_Diode
Q16  Net-_Q15-Pad3_ Net-_D5-Pad2_ Net-_D1-Pad2_ eSim_NPN
Q15  Net-_D11-Pad1_ Net-_Q15-Pad2_ Net-_Q15-Pad3_ eSim_NPN
Q17  Net-_D11-Pad1_ Net-_Q15-Pad3_ Net-_Q17-Pad3_ eSim_NPN
D7  Net-_D7-Pad1_ Net-_D7-Pad2_ eSim_Diode
D8  Net-_D7-Pad1_ Net-_D8-Pad2_ eSim_Diode
U1  Net-_Q1-Pad1_ Net-_D7-Pad1_ Net-_D8-Pad2_ Net-_D7-Pad2_ Net-_Q10-Pad1_ Net-_D1-Pad2_ Net-_Q15-Pad2_ Net-_Q17-Pad3_ Net-_Q34-Pad3_ Net-_Q32-Pad2_ Net-_D11-Pad1_ Net-_Q26-Pad1_ Net-_D9-Pad2_ Net-_D12-Pad2_ Net-_D12-Pad1_ Net-_Q18-Pad1_ PORT
Q20  Net-_Q19-Pad1_ Net-_D11-Pad2_ Net-_D11-Pad1_ eSim_PNP
Q22  Net-_Q22-Pad1_ Net-_Q19-Pad1_ Net-_D11-Pad2_ eSim_PNP
D11  Net-_D11-Pad1_ Net-_D11-Pad2_ eSim_Diode
Q19  Net-_Q19-Pad1_ Net-_D9-Pad2_ Net-_Q19-Pad3_ eSim_NPN
Q23  Net-_Q23-Pad1_ Net-_D12-Pad2_ Net-_Q19-Pad3_ eSim_NPN
Q21  Net-_Q19-Pad3_ Net-_Q18-Pad1_ Net-_D10-Pad1_ eSim_NPN
Q18  Net-_Q18-Pad1_ Net-_D10-Pad1_ Net-_D1-Pad2_ eSim_NPN
D10  Net-_D10-Pad1_ Net-_D1-Pad2_ eSim_Diode
Q24  Net-_Q23-Pad1_ Net-_D13-Pad2_ Net-_D11-Pad1_ eSim_PNP
Q26  Net-_Q26-Pad1_ Net-_Q23-Pad1_ Net-_D13-Pad2_ eSim_PNP
D13  Net-_D11-Pad1_ Net-_D13-Pad2_ eSim_Diode
Q27  Net-_Q26-Pad1_ Net-_Q22-Pad1_ Net-_D14-Pad1_ eSim_NPN
Q25  Net-_Q22-Pad1_ Net-_D14-Pad1_ Net-_D1-Pad2_ eSim_NPN
D14  Net-_D14-Pad1_ Net-_D1-Pad2_ eSim_Diode
Q28  Net-_Q28-Pad1_ Net-_Q28-Pad1_ Net-_D11-Pad1_ eSim_PNP
Q30  Net-_D15-Pad1_ Net-_Q28-Pad1_ Net-_D11-Pad1_ eSim_PNP
Q29  Net-_Q28-Pad1_ Net-_D10-Pad1_ Net-_Q29-Pad3_ eSim_NPN
Q31  Net-_Q28-Pad1_ Net-_D15-Pad1_ Net-_Q29-Pad3_ eSim_NPN
R1  Net-_Q29-Pad3_ Net-_D1-Pad2_ 1k
D15  Net-_D15-Pad1_ Net-_D15-Pad2_ eSim_Diode
D16  Net-_D15-Pad2_ Net-_D1-Pad2_ eSim_Diode
Q33  Net-_Q32-Pad3_ Net-_D15-Pad2_ Net-_D1-Pad2_ eSim_NPN
Q32  Net-_D11-Pad1_ Net-_Q32-Pad2_ Net-_Q32-Pad3_ eSim_NPN
Q34  Net-_D11-Pad1_ Net-_Q32-Pad3_ Net-_Q34-Pad3_ eSim_NPN
D9  Net-_D12-Pad1_ Net-_D9-Pad2_ eSim_Diode
D12  Net-_D12-Pad1_ Net-_D12-Pad2_ eSim_Diode

.end
