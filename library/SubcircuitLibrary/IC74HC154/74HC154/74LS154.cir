.title KiCad schematic
U11 Net-_X1-Pad5_ Net-_U11-Pad2_ d_inverter
U10 Net-_U10-Pad1_ Net-_X1-Pad5_ d_inverter
U2 Net-_U1-Pad2_ Net-_U2-Pad2_ Net-_U2-Pad3_ Net-_U2-Pad4_ Net-_U2-Pad5_ Net-_U12-Pad2_ Net-_U13-Pad2_ Net-_U16-Pad2_ Net-_U19-Pad2_ Net-_U2-Pad10_ Net-_U2-Pad11_ GND Net-_U2-Pad13_ Net-_U2-Pad14_ Net-_U2-Pad15_ Net-_U2-Pad16_ Net-_U2-Pad17_ Net-_U2-Pad18_ Net-_U2-Pad19_ Net-_U2-Pad20_ Net-_U17-Pad1_ Net-_U14-Pad1_ Net-_U10-Pad1_ GND PORT
U14 Net-_U14-Pad1_ Net-_X1-Pad4_ d_inverter
U21 Net-_U2-Pad20_ Net-_U21-Pad2_ d_inverter
U17 Net-_U17-Pad1_ Net-_X1-Pad3_ d_inverter
U3 Net-_U2-Pad18_ Net-_U3-Pad2_ d_inverter
U5 Net-_U2-Pad19_ Net-_U4-Pad2_ d_inverter
U4 Net-_U3-Pad2_ Net-_U4-Pad2_ Net-_U4-Pad3_ d_and
U9 Net-_U9-Pad1_ Net-_U2-Pad5_ d_inverter
X6 Net-_U4-Pad3_ Net-_X1-Pad4_ Net-_U21-Pad2_ Net-_U11-Pad2_ Net-_U18-Pad2_ Net-_U12-Pad1_ 5_and
X5 Net-_U4-Pad3_ Net-_X1-Pad5_ Net-_X1-Pad4_ Net-_U21-Pad2_ Net-_U18-Pad2_ Net-_U9-Pad1_ 5_and
X1 Net-_U4-Pad3_ Net-_U21-Pad2_ Net-_X1-Pad3_ Net-_X1-Pad4_ Net-_X1-Pad5_ Net-_U1-Pad1_ 5_and
U1 Net-_U1-Pad1_ Net-_U1-Pad2_ d_inverter
X2 Net-_U4-Pad3_ Net-_X1-Pad4_ Net-_X1-Pad3_ Net-_U21-Pad2_ Net-_U11-Pad2_ Net-_U6-Pad1_ 5_and
U6 Net-_U6-Pad1_ Net-_U2-Pad2_ d_inverter
U7 Net-_U7-Pad1_ Net-_U2-Pad3_ d_inverter
U8 Net-_U8-Pad1_ Net-_U2-Pad4_ d_inverter
X3 Net-_U4-Pad3_ Net-_X1-Pad5_ Net-_X1-Pad3_ Net-_U21-Pad2_ Net-_X11-Pad4_ Net-_U7-Pad1_ 5_and
X4 Net-_U4-Pad3_ Net-_X1-Pad3_ Net-_U21-Pad2_ Net-_U11-Pad2_ Net-_X11-Pad4_ Net-_U8-Pad1_ 5_and
U22 Net-_U21-Pad2_ Net-_U22-Pad2_ d_inverter
U15 Net-_X1-Pad4_ Net-_X11-Pad4_ d_inverter
U18 Net-_X1-Pad3_ Net-_U18-Pad2_ d_inverter
U26 Net-_U26-Pad1_ Net-_U2-Pad15_ d_inverter
X14 Net-_U4-Pad3_ Net-_X1-Pad4_ Net-_U11-Pad2_ Net-_U18-Pad2_ Net-_U22-Pad2_ Net-_U26-Pad1_ 5_and
X15 Net-_U4-Pad3_ Net-_X1-Pad5_ Net-_X11-Pad4_ Net-_U18-Pad2_ Net-_U22-Pad2_ Net-_U27-Pad1_ 5_and
U27 Net-_U27-Pad1_ Net-_U2-Pad16_ d_inverter
X16 Net-_U4-Pad3_ Net-_U11-Pad2_ Net-_X11-Pad4_ Net-_U18-Pad2_ Net-_U22-Pad2_ Net-_U28-Pad1_ 5_and
U28 Net-_U28-Pad1_ Net-_U2-Pad17_ d_inverter
X12 Net-_U4-Pad3_ Net-_X1-Pad3_ Net-_U11-Pad2_ Net-_X11-Pad4_ Net-_U22-Pad2_ Net-_U24-Pad1_ 5_and
X13 Net-_U4-Pad3_ Net-_X1-Pad5_ Net-_X1-Pad4_ Net-_U18-Pad2_ Net-_U22-Pad2_ Net-_U25-Pad1_ 5_and
U25 Net-_U25-Pad1_ Net-_U2-Pad14_ d_inverter
U24 Net-_U24-Pad1_ Net-_U2-Pad13_ d_inverter
X7 Net-_U4-Pad3_ Net-_X1-Pad5_ Net-_U21-Pad2_ Net-_X11-Pad4_ Net-_U18-Pad2_ Net-_U13-Pad1_ 5_and
X8 Net-_U4-Pad3_ Net-_U21-Pad2_ Net-_U11-Pad2_ Net-_X11-Pad4_ Net-_U18-Pad2_ Net-_U16-Pad1_ 5_and
U12 Net-_U12-Pad1_ Net-_U12-Pad2_ d_inverter
U13 Net-_U13-Pad1_ Net-_U13-Pad2_ d_inverter
U20 Net-_U20-Pad1_ Net-_U2-Pad10_ d_inverter
U19 Net-_U19-Pad1_ Net-_U19-Pad2_ d_inverter
X10 Net-_U4-Pad3_ Net-_X1-Pad4_ Net-_X1-Pad3_ Net-_U11-Pad2_ Net-_U22-Pad2_ Net-_U20-Pad1_ 5_and
X11 Net-_U4-Pad3_ Net-_X1-Pad5_ Net-_X1-Pad3_ Net-_X11-Pad4_ Net-_U22-Pad2_ Net-_U23-Pad1_ 5_and
X9 Net-_U4-Pad3_ Net-_X1-Pad5_ Net-_X1-Pad4_ Net-_X1-Pad3_ Net-_U22-Pad2_ Net-_U19-Pad1_ 5_and
U23 Net-_U23-Pad1_ Net-_U2-Pad11_ d_inverter
U16 Net-_U16-Pad1_ Net-_U16-Pad2_ d_inverter
.end
