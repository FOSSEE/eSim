* C:\FOSSEE\eSim\library\SubcircuitLibrary\SN74116\SN74116.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 07/05/25 18:51:59

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U3  Net-_U3-Pad1_ Net-_U3-Pad2_ d_inverter
U4  Net-_U1-Pad2_ Net-_U2-Pad2_ Net-_U10-Pad1_ d_and
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ d_inverter
U2  Net-_U2-Pad1_ Net-_U2-Pad2_ d_inverter
U6  Net-_U10-Pad1_ Net-_U14-Pad2_ d_inverter
U14  Net-_U14-Pad1_ Net-_U14-Pad2_ Net-_U14-Pad3_ d_nand
U16  Net-_U10-Pad1_ Net-_U15-Pad2_ Net-_U16-Pad3_ d_and
U15  Net-_U14-Pad1_ Net-_U15-Pad2_ Net-_U15-Pad3_ d_and
U30  Net-_U15-Pad3_ Net-_U16-Pad3_ Net-_U30-Pad3_ d_nor
U36  Net-_U14-Pad3_ Net-_U30-Pad3_ Net-_U36-Pad3_ d_and
U54  Net-_U43-Pad2_ Net-_U44-Pad2_ Net-_U14-Pad1_ d_and
U44  Net-_U36-Pad3_ Net-_U44-Pad2_ d_inverter
U5  Net-_U10-Pad1_ Net-_U11-Pad2_ d_inverter
U11  Net-_U11-Pad1_ Net-_U11-Pad2_ Net-_U11-Pad3_ d_nand
U13  Net-_U10-Pad1_ Net-_U12-Pad2_ Net-_U13-Pad3_ d_and
U12  Net-_U11-Pad1_ Net-_U12-Pad2_ Net-_U12-Pad3_ d_and
U29  Net-_U12-Pad3_ Net-_U13-Pad3_ Net-_U29-Pad3_ d_nor
U35  Net-_U11-Pad3_ Net-_U29-Pad3_ Net-_U35-Pad3_ d_and
U53  Net-_U41-Pad2_ Net-_U42-Pad2_ Net-_U11-Pad1_ d_and
U41  Net-_U3-Pad2_ Net-_U41-Pad2_ d_inverter
U42  Net-_U35-Pad3_ Net-_U42-Pad2_ d_inverter
U9  Net-_U10-Pad1_ Net-_U10-Pad2_ d_inverter
U23  Net-_U23-Pad1_ Net-_U10-Pad2_ Net-_U23-Pad3_ d_nand
U27  Net-_U10-Pad1_ Net-_U25-Pad2_ Net-_U27-Pad3_ d_and
U25  Net-_U23-Pad1_ Net-_U25-Pad2_ Net-_U25-Pad3_ d_and
U33  Net-_U25-Pad3_ Net-_U27-Pad3_ Net-_U33-Pad3_ d_nor
U39  Net-_U23-Pad3_ Net-_U33-Pad3_ Net-_U39-Pad3_ d_and
U57  Net-_U49-Pad2_ Net-_U51-Pad2_ Net-_U23-Pad1_ d_and
U49  Net-_U3-Pad2_ Net-_U49-Pad2_ d_inverter
U51  Net-_U39-Pad3_ Net-_U51-Pad2_ d_inverter
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ d_inverter
U24  Net-_U23-Pad1_ Net-_U10-Pad2_ Net-_U23-Pad3_ d_nand
U28  Net-_U10-Pad1_ Net-_U25-Pad2_ Net-_U27-Pad3_ d_and
U26  Net-_U23-Pad1_ Net-_U25-Pad2_ Net-_U25-Pad3_ d_and
U34  Net-_U25-Pad3_ Net-_U27-Pad3_ Net-_U33-Pad3_ d_nor
U40  Net-_U23-Pad3_ Net-_U33-Pad3_ Net-_U39-Pad3_ d_and
U58  Net-_U49-Pad2_ Net-_U51-Pad2_ Net-_U23-Pad1_ d_and
U50  Net-_U3-Pad2_ Net-_U49-Pad2_ d_inverter
U52  Net-_U39-Pad3_ Net-_U51-Pad2_ d_inverter
U7  Net-_U10-Pad1_ Net-_U17-Pad2_ d_inverter
U17  Net-_U17-Pad1_ Net-_U17-Pad2_ Net-_U17-Pad3_ d_nand
U21  Net-_U10-Pad1_ Net-_U19-Pad2_ Net-_U21-Pad3_ d_and
U19  Net-_U17-Pad1_ Net-_U19-Pad2_ Net-_U19-Pad3_ d_and
U31  Net-_U19-Pad3_ Net-_U21-Pad3_ Net-_U31-Pad3_ d_nor
U37  Net-_U17-Pad3_ Net-_U31-Pad3_ Net-_U37-Pad3_ d_and
U55  Net-_U45-Pad2_ Net-_U47-Pad2_ Net-_U17-Pad1_ d_and
U45  Net-_U3-Pad2_ Net-_U45-Pad2_ d_inverter
U47  Net-_U37-Pad3_ Net-_U47-Pad2_ d_inverter
U8  Net-_U10-Pad1_ Net-_U17-Pad2_ d_inverter
U18  Net-_U17-Pad1_ Net-_U17-Pad2_ Net-_U17-Pad3_ d_nand
U22  Net-_U10-Pad1_ Net-_U19-Pad2_ Net-_U21-Pad3_ d_and
U20  Net-_U17-Pad1_ Net-_U19-Pad2_ Net-_U19-Pad3_ d_and
U32  Net-_U19-Pad3_ Net-_U21-Pad3_ Net-_U31-Pad3_ d_nor
U38  Net-_U17-Pad3_ Net-_U31-Pad3_ Net-_U37-Pad3_ d_and
U56  Net-_U45-Pad2_ Net-_U47-Pad2_ Net-_U17-Pad1_ d_and
U46  Net-_U3-Pad2_ Net-_U45-Pad2_ d_inverter
U48  Net-_U37-Pad3_ Net-_U47-Pad2_ d_inverter
U43  Net-_U3-Pad2_ Net-_U43-Pad2_ d_inverter
U62  Net-_U59-Pad13_ Net-_U100-Pad1_ d_inverter
U63  Net-_U60-Pad2_ Net-_U61-Pad2_ Net-_U63-Pad3_ d_and
U60  Net-_U59-Pad14_ Net-_U60-Pad2_ d_inverter
U61  Net-_U59-Pad15_ Net-_U61-Pad2_ d_inverter
U65  Net-_U63-Pad3_ Net-_U65-Pad2_ d_inverter
U73  Net-_U113-Pad3_ Net-_U65-Pad2_ Net-_U73-Pad3_ d_nand
U75  Net-_U63-Pad3_ Net-_U59-Pad16_ Net-_U75-Pad3_ d_and
U74  Net-_U113-Pad3_ Net-_U59-Pad16_ Net-_U74-Pad3_ d_and
U89  Net-_U74-Pad3_ Net-_U75-Pad3_ Net-_U89-Pad3_ d_nor
U95  Net-_U73-Pad3_ Net-_U89-Pad3_ Net-_U103-Pad1_ d_and
U113  Net-_U102-Pad2_ Net-_U103-Pad2_ Net-_U113-Pad3_ d_and
U103  Net-_U103-Pad1_ Net-_U103-Pad2_ d_inverter
U64  Net-_U63-Pad3_ Net-_U64-Pad2_ d_inverter
U70  Net-_U112-Pad3_ Net-_U64-Pad2_ Net-_U70-Pad3_ d_nand
U72  Net-_U63-Pad3_ Net-_U59-Pad18_ Net-_U72-Pad3_ d_and
U71  Net-_U112-Pad3_ Net-_U59-Pad18_ Net-_U71-Pad3_ d_and
U88  Net-_U71-Pad3_ Net-_U72-Pad3_ Net-_U88-Pad3_ d_nor
U94  Net-_U70-Pad3_ Net-_U88-Pad3_ Net-_U101-Pad1_ d_and
U112  Net-_U100-Pad2_ Net-_U101-Pad2_ Net-_U112-Pad3_ d_and
U100  Net-_U100-Pad1_ Net-_U100-Pad2_ d_inverter
U101  Net-_U101-Pad1_ Net-_U101-Pad2_ d_inverter
U68  Net-_U63-Pad3_ Net-_U68-Pad2_ d_inverter
U82  Net-_U116-Pad3_ Net-_U68-Pad2_ Net-_U82-Pad3_ d_nand
U86  Net-_U63-Pad3_ Net-_U59-Pad22_ Net-_U86-Pad3_ d_and
U84  Net-_U116-Pad3_ Net-_U59-Pad22_ Net-_U84-Pad3_ d_and
U92  Net-_U84-Pad3_ Net-_U86-Pad3_ Net-_U92-Pad3_ d_nor
U98  Net-_U82-Pad3_ Net-_U92-Pad3_ Net-_U110-Pad1_ d_and
U116  Net-_U108-Pad2_ Net-_U110-Pad2_ Net-_U116-Pad3_ d_and
U108  Net-_U100-Pad1_ Net-_U108-Pad2_ d_inverter
U110  Net-_U110-Pad1_ Net-_U110-Pad2_ d_inverter
U69  Net-_U63-Pad3_ Net-_U68-Pad2_ d_inverter
U83  Net-_U116-Pad3_ Net-_U68-Pad2_ Net-_U82-Pad3_ d_nand
U87  Net-_U63-Pad3_ Net-_U59-Pad22_ Net-_U86-Pad3_ d_and
U85  Net-_U116-Pad3_ Net-_U59-Pad22_ Net-_U84-Pad3_ d_and
U93  Net-_U84-Pad3_ Net-_U86-Pad3_ Net-_U92-Pad3_ d_nor
U99  Net-_U82-Pad3_ Net-_U92-Pad3_ Net-_U110-Pad1_ d_and
U117  Net-_U108-Pad2_ Net-_U110-Pad2_ Net-_U116-Pad3_ d_and
U109  Net-_U100-Pad1_ Net-_U108-Pad2_ d_inverter
U111  Net-_U110-Pad1_ Net-_U110-Pad2_ d_inverter
U66  Net-_U63-Pad3_ Net-_U66-Pad2_ d_inverter
U76  Net-_U114-Pad3_ Net-_U66-Pad2_ Net-_U76-Pad3_ d_nand
U80  Net-_U63-Pad3_ Net-_U59-Pad20_ Net-_U80-Pad3_ d_and
U78  Net-_U114-Pad3_ Net-_U59-Pad20_ Net-_U78-Pad3_ d_and
U90  Net-_U78-Pad3_ Net-_U80-Pad3_ Net-_U90-Pad3_ d_nor
U96  Net-_U76-Pad3_ Net-_U90-Pad3_ Net-_U106-Pad1_ d_and
U114  Net-_U104-Pad2_ Net-_U106-Pad2_ Net-_U114-Pad3_ d_and
U104  Net-_U100-Pad1_ Net-_U104-Pad2_ d_inverter
U106  Net-_U106-Pad1_ Net-_U106-Pad2_ d_inverter
U67  Net-_U63-Pad3_ Net-_U66-Pad2_ d_inverter
U77  Net-_U114-Pad3_ Net-_U66-Pad2_ Net-_U76-Pad3_ d_nand
U81  Net-_U63-Pad3_ Net-_U59-Pad20_ Net-_U80-Pad3_ d_and
U79  Net-_U114-Pad3_ Net-_U59-Pad20_ Net-_U78-Pad3_ d_and
U91  Net-_U78-Pad3_ Net-_U80-Pad3_ Net-_U90-Pad3_ d_nor
U97  Net-_U76-Pad3_ Net-_U90-Pad3_ Net-_U106-Pad1_ d_and
U115  Net-_U104-Pad2_ Net-_U106-Pad2_ Net-_U114-Pad3_ d_and
U105  Net-_U100-Pad1_ Net-_U104-Pad2_ d_inverter
U107  Net-_U106-Pad1_ Net-_U106-Pad2_ d_inverter
U102  Net-_U100-Pad1_ Net-_U102-Pad2_ d_inverter
U59  Net-_U3-Pad1_ Net-_U1-Pad1_ Net-_U2-Pad1_ Net-_U15-Pad2_ Net-_U14-Pad1_ Net-_U12-Pad2_ Net-_U11-Pad1_ Net-_U19-Pad2_ Net-_U17-Pad1_ Net-_U25-Pad2_ Net-_U23-Pad1_ ? Net-_U59-Pad13_ Net-_U59-Pad14_ Net-_U59-Pad15_ Net-_U59-Pad16_ Net-_U113-Pad3_ Net-_U59-Pad18_ Net-_U112-Pad3_ Net-_U59-Pad20_ Net-_U114-Pad3_ Net-_U59-Pad22_ Net-_U116-Pad3_ ? PORT

.end
