* C:\FOSSEE2\eSim\library\SubcircuitLibrary\SC_SL74HC154\SC_SL74HC154.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/15/25 17:03:24

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U10  Net-_U1-Pad18_ Net-_U1-Pad19_ Net-_U10-Pad3_ d_nor
U9  Net-_U1-Pad19_ Net-_U1-Pad18_ Net-_U9-Pad3_ d_nor
X1  Net-_U11-Pad1_ Net-_U2-Pad2_ Net-_U4-Pad2_ Net-_U5-Pad2_ Net-_U10-Pad3_ Net-_U12-Pad1_ 5_and
X2  Net-_U11-Pad2_ Net-_U2-Pad2_ Net-_U4-Pad2_ Net-_U5-Pad2_ Net-_U10-Pad3_ Net-_U13-Pad1_ 5_and
X3  Net-_U11-Pad1_ Net-_U6-Pad2_ Net-_U4-Pad2_ Net-_U5-Pad2_ Net-_U10-Pad3_ Net-_U14-Pad1_ 5_and
X4  Net-_U11-Pad2_ Net-_U6-Pad2_ Net-_U4-Pad2_ Net-_U5-Pad2_ Net-_U10-Pad3_ Net-_U15-Pad1_ 5_and
X5  Net-_U11-Pad1_ Net-_U2-Pad2_ Net-_U7-Pad2_ Net-_U5-Pad2_ Net-_U10-Pad3_ Net-_U16-Pad1_ 5_and
X6  Net-_U11-Pad2_ Net-_U2-Pad2_ Net-_U7-Pad2_ Net-_U5-Pad2_ Net-_U10-Pad3_ Net-_U17-Pad1_ 5_and
X7  Net-_U11-Pad1_ Net-_U6-Pad2_ Net-_U7-Pad2_ Net-_U5-Pad2_ Net-_U10-Pad3_ Net-_U18-Pad1_ 5_and
X8  Net-_U11-Pad2_ Net-_U6-Pad2_ Net-_U7-Pad2_ Net-_U5-Pad2_ Net-_U10-Pad3_ Net-_U19-Pad1_ 5_and
X9  Net-_U11-Pad1_ Net-_U2-Pad2_ Net-_U4-Pad2_ Net-_U8-Pad2_ Net-_U10-Pad3_ Net-_U20-Pad1_ 5_and
X10  Net-_U11-Pad2_ Net-_U2-Pad2_ Net-_U4-Pad2_ Net-_U8-Pad2_ Net-_U9-Pad3_ Net-_U21-Pad1_ 5_and
X11  Net-_U11-Pad1_ Net-_U6-Pad2_ Net-_U4-Pad2_ Net-_U8-Pad2_ Net-_U9-Pad3_ Net-_U22-Pad1_ 5_and
X12  Net-_U11-Pad2_ Net-_U6-Pad2_ Net-_U4-Pad2_ Net-_U8-Pad2_ Net-_U9-Pad3_ Net-_U23-Pad1_ 5_and
X13  Net-_U11-Pad1_ Net-_U2-Pad2_ Net-_U7-Pad2_ Net-_U8-Pad2_ Net-_U9-Pad3_ Net-_U24-Pad1_ 5_and
X14  Net-_U11-Pad2_ Net-_U2-Pad2_ Net-_U7-Pad2_ Net-_U8-Pad2_ Net-_U9-Pad3_ Net-_U25-Pad1_ 5_and
X15  Net-_U11-Pad1_ Net-_U6-Pad2_ Net-_U7-Pad2_ Net-_U8-Pad2_ Net-_U9-Pad3_ Net-_U26-Pad1_ 5_and
X16  Net-_U11-Pad2_ Net-_U6-Pad2_ Net-_U7-Pad2_ Net-_U8-Pad2_ Net-_U9-Pad3_ Net-_U27-Pad1_ 5_and
U12  Net-_U12-Pad1_ Net-_U1-Pad1_ d_inverter
U13  Net-_U13-Pad1_ Net-_U1-Pad2_ d_inverter
U14  Net-_U14-Pad1_ Net-_U1-Pad3_ d_inverter
U15  Net-_U15-Pad1_ Net-_U1-Pad4_ d_inverter
U16  Net-_U16-Pad1_ Net-_U1-Pad5_ d_inverter
U17  Net-_U17-Pad1_ Net-_U1-Pad6_ d_inverter
U18  Net-_U18-Pad1_ Net-_U1-Pad7_ d_inverter
U19  Net-_U19-Pad1_ Net-_U1-Pad8_ d_inverter
U20  Net-_U20-Pad1_ Net-_U1-Pad9_ d_inverter
U21  Net-_U21-Pad1_ Net-_U1-Pad10_ d_inverter
U22  Net-_U22-Pad1_ Net-_U1-Pad11_ d_inverter
U23  Net-_U23-Pad1_ Net-_U1-Pad13_ d_inverter
U24  Net-_U24-Pad1_ Net-_U1-Pad14_ d_inverter
U25  Net-_U25-Pad1_ Net-_U1-Pad15_ d_inverter
U26  Net-_U26-Pad1_ Net-_U1-Pad16_ d_inverter
U27  Net-_U27-Pad1_ Net-_U1-Pad17_ d_inverter
U3  Net-_U1-Pad23_ Net-_U11-Pad1_ d_inverter
U11  Net-_U11-Pad1_ Net-_U11-Pad2_ d_inverter
U2  Net-_U1-Pad22_ Net-_U2-Pad2_ d_inverter
U6  Net-_U2-Pad2_ Net-_U6-Pad2_ d_inverter
U4  Net-_U1-Pad21_ Net-_U4-Pad2_ d_inverter
U7  Net-_U4-Pad2_ Net-_U7-Pad2_ d_inverter
U5  Net-_U1-Pad20_ Net-_U5-Pad2_ d_inverter
U8  Net-_U5-Pad2_ Net-_U8-Pad2_ d_inverter
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ ? Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ Net-_U1-Pad16_ Net-_U1-Pad17_ Net-_U1-Pad18_ Net-_U1-Pad19_ Net-_U1-Pad20_ Net-_U1-Pad21_ Net-_U1-Pad22_ Net-_U1-Pad23_ ? PORT

.end
