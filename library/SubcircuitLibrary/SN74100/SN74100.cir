* C:\FOSSEE\eSim\library\SubcircuitLibrary\SN74100\SN74100.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/02/25 11:52:06

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U5  Net-_U11-Pad2_ Net-_U3-Pad2_ d_inverter
U7  Net-_U11-Pad2_ Net-_U11-Pad23_ Net-_U7-Pad3_ d_and
U3  Net-_U11-Pad23_ Net-_U3-Pad2_ Net-_U2-Pad2_ d_and
U2  Net-_U2-Pad1_ Net-_U2-Pad2_ Net-_U11-Pad5_ d_nor
U4  Net-_U4-Pad1_ Net-_U2-Pad1_ d_buffer
U6  Net-_U11-Pad5_ Net-_U6-Pad2_ d_buffer
U8  Net-_U7-Pad3_ Net-_U6-Pad2_ Net-_U4-Pad1_ d_nor
U18  Net-_U11-Pad3_ Net-_U12-Pad2_ d_inverter
U24  Net-_U11-Pad3_ Net-_U11-Pad23_ Net-_U24-Pad3_ d_and
U12  Net-_U11-Pad23_ Net-_U12-Pad2_ Net-_U1-Pad2_ d_and
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ d_nor
U15  Net-_U15-Pad1_ Net-_U1-Pad1_ d_buffer
U21  Net-_U1-Pad3_ Net-_U21-Pad2_ d_buffer
U27  Net-_U24-Pad3_ Net-_U21-Pad2_ Net-_U15-Pad1_ d_nor
U42  Net-_U11-Pad11_ Net-_U34-Pad2_ d_inverter
U49  Net-_U11-Pad11_ Net-_U11-Pad12_ Net-_U49-Pad3_ d_and
U34  Net-_U11-Pad12_ Net-_U34-Pad2_ Net-_U30-Pad2_ d_and
U30  Net-_U30-Pad1_ Net-_U30-Pad2_ Net-_U11-Pad8_ d_nor
U38  Net-_U38-Pad1_ Net-_U30-Pad1_ d_buffer
U46  Net-_U11-Pad8_ Net-_U46-Pad2_ d_buffer
U54  Net-_U49-Pad3_ Net-_U46-Pad2_ Net-_U38-Pad1_ d_nor
U43  Net-_U11-Pad10_ Net-_U35-Pad2_ d_inverter
U51  Net-_U11-Pad10_ Net-_U11-Pad12_ Net-_U51-Pad3_ d_and
U35  Net-_U11-Pad12_ Net-_U35-Pad2_ Net-_U31-Pad2_ d_and
U31  Net-_U31-Pad1_ Net-_U31-Pad2_ Net-_U11-Pad9_ d_nor
U39  Net-_U39-Pad1_ Net-_U31-Pad1_ d_buffer
U47  Net-_U11-Pad9_ Net-_U47-Pad2_ d_buffer
U55  Net-_U51-Pad3_ Net-_U47-Pad2_ Net-_U39-Pad1_ d_nor
U19  Net-_U11-Pad22_ Net-_U13-Pad2_ d_inverter
U25  Net-_U11-Pad22_ Net-_U11-Pad23_ Net-_U25-Pad3_ d_and
U13  Net-_U11-Pad23_ Net-_U13-Pad2_ Net-_U13-Pad3_ d_and
U9  Net-_U16-Pad2_ Net-_U13-Pad3_ Net-_U11-Pad19_ d_nor
U16  Net-_U16-Pad1_ Net-_U16-Pad2_ d_buffer
U22  Net-_U11-Pad19_ Net-_U22-Pad2_ d_buffer
U28  Net-_U25-Pad3_ Net-_U22-Pad2_ Net-_U16-Pad1_ d_nor
U20  Net-_U11-Pad21_ Net-_U14-Pad2_ d_inverter
U26  Net-_U11-Pad21_ Net-_U11-Pad23_ Net-_U26-Pad3_ d_and
U14  Net-_U11-Pad23_ Net-_U14-Pad2_ Net-_U10-Pad2_ d_and
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ Net-_U10-Pad3_ d_nor
U17  Net-_U17-Pad1_ Net-_U10-Pad1_ d_buffer
U23  Net-_U10-Pad3_ Net-_U23-Pad2_ d_buffer
U29  Net-_U26-Pad3_ Net-_U23-Pad2_ Net-_U17-Pad1_ d_nor
U44  Net-_U11-Pad15_ Net-_U36-Pad2_ d_inverter
U52  Net-_U11-Pad15_ Net-_U11-Pad12_ Net-_U52-Pad3_ d_and
U36  Net-_U11-Pad12_ Net-_U36-Pad2_ Net-_U32-Pad2_ d_and
U32  Net-_U32-Pad1_ Net-_U32-Pad2_ Net-_U11-Pad18_ d_nor
U40  Net-_U40-Pad1_ Net-_U32-Pad1_ d_buffer
U48  Net-_U11-Pad18_ Net-_U48-Pad2_ d_buffer
U56  Net-_U52-Pad3_ Net-_U48-Pad2_ Net-_U40-Pad1_ d_nor
U45  Net-_U11-Pad16_ Net-_U37-Pad2_ d_inverter
U53  Net-_U11-Pad16_ Net-_U11-Pad12_ Net-_U53-Pad3_ d_and
U37  Net-_U11-Pad12_ Net-_U37-Pad2_ Net-_U33-Pad2_ d_and
U33  Net-_U33-Pad1_ Net-_U33-Pad2_ Net-_U11-Pad17_ d_nor
U41  Net-_U41-Pad1_ Net-_U33-Pad1_ d_buffer
U50  Net-_U11-Pad17_ Net-_U50-Pad2_ d_buffer
U57  Net-_U53-Pad3_ Net-_U50-Pad2_ Net-_U41-Pad1_ d_nor
U11  ? Net-_U11-Pad2_ Net-_U11-Pad3_ Net-_U1-Pad3_ Net-_U11-Pad5_ ? ? Net-_U11-Pad8_ Net-_U11-Pad9_ Net-_U11-Pad10_ Net-_U11-Pad11_ Net-_U11-Pad12_ ? ? Net-_U11-Pad15_ Net-_U11-Pad16_ Net-_U11-Pad17_ Net-_U11-Pad18_ Net-_U11-Pad19_ Net-_U10-Pad3_ Net-_U11-Pad21_ Net-_U11-Pad22_ Net-_U11-Pad23_ ? PORT

.end
