* C:\Users\AJAY\OneDrive\Desktop\FOSSEE2.3\eSim\library\SubcircuitLibrary\CA3085\CA3085.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 12/21/25 19:14:37

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
R1  Net-_D2-Pad1_ Net-_D1-Pad1_ 40k
U2  Net-_D3-Pad2_ Net-_D1-Pad1_ zener
D1  Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
Q1  Net-_D1-Pad2_ Net-_Q1-Pad2_ Net-_D2-Pad2_ eSim_PNP
D2  Net-_D2-Pad1_ Net-_D2-Pad2_ eSim_Diode
U3  Net-_D3-Pad2_ Net-_D1-Pad2_ zener
Q2  Net-_Q1-Pad2_ Net-_D2-Pad2_ Net-_D2-Pad1_ eSim_PNP
Q3  Net-_Q1-Pad2_ Net-_D1-Pad2_ ? eSim_NPN
R2  ? Net-_Q4-Pad2_ 4k
R3  Net-_Q4-Pad2_ Net-_D3-Pad1_ 1.5k
D3  Net-_D3-Pad1_ Net-_D3-Pad2_ eSim_Diode
Q4  Net-_Q4-Pad1_ Net-_Q4-Pad2_ Net-_Q4-Pad3_ eSim_NPN
Q5  Net-_Q4-Pad1_ Net-_D4-Pad2_ Net-_D2-Pad1_ eSim_PNP
D4  Net-_D2-Pad1_ Net-_D4-Pad2_ eSim_Diode
Q7  Net-_Q10-Pad2_ Net-_Q4-Pad1_ Net-_D4-Pad2_ eSim_PNP
Q8  Net-_Q10-Pad2_ Net-_Q8-Pad2_ Net-_Q4-Pad3_ eSim_NPN
Q6  Net-_Q4-Pad3_ Net-_D3-Pad1_ Net-_D3-Pad2_ eSim_NPN
Q10  Net-_D2-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
Q9  Net-_Q10-Pad2_ Net-_Q9-Pad2_ Net-_Q9-Pad3_ eSim_NPN
R4  Net-_Q9-Pad2_ Net-_Q11-Pad3_ 1.5k
Q11  Net-_Q11-Pad1_ Net-_Q10-Pad3_ Net-_Q11-Pad3_ eSim_NPN
R5  Net-_D2-Pad1_ Net-_Q11-Pad1_ 500
U1  Net-_Q11-Pad3_ Net-_Q11-Pad1_ Net-_D2-Pad1_ Net-_D3-Pad2_ Net-_Q4-Pad2_ Net-_Q8-Pad2_ Net-_Q10-Pad2_ Net-_Q9-Pad3_ PORT

.end
