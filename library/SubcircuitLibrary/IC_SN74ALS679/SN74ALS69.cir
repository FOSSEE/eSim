* E:\FOSSEE\eSim\library\SubcircuitLibrary\SN74ALS69\SN74ALS69.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 05/27/25 13:01:32

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U2  Net-_U1-Pad1_ Net-_U15-Pad1_ d_inverter
U3  Net-_U1-Pad2_ Net-_U12-Pad1_ d_inverter
U4  Net-_U1-Pad3_ Net-_U10-Pad1_ d_inverter
U5  Net-_U1-Pad4_ Net-_U10-Pad2_ d_inverter
U7  Net-_U6-Pad2_ Net-_U46-Pad2_ d_buffer
U6  Net-_U1-Pad5_ Net-_U6-Pad2_ d_inverter
X4  Net-_U15-Pad1_ Net-_U12-Pad1_ Net-_U10-Pad1_ Net-_U10-Pad2_ Net-_U21-Pad1_ 4_and
U21  Net-_U21-Pad1_ Net-_U21-Pad2_ d_inverter
U30  Net-_U21-Pad2_ Net-_U1-Pad6_ Net-_U30-Pad3_ d_xor
X5  Net-_U12-Pad1_ Net-_U10-Pad1_ Net-_U10-Pad2_ Net-_U22-Pad1_ 3_and
U31  Net-_U22-Pad2_ ? Net-_U31-Pad3_ d_xor
U22  Net-_U22-Pad1_ Net-_U22-Pad2_ d_inverter
X2  Net-_U15-Pad1_ Net-_U10-Pad1_ Net-_U10-Pad2_ Net-_U23-Pad1_ 3_and
X3  Net-_U12-Pad1_ Net-_U10-Pad1_ Net-_U10-Pad2_ Net-_U23-Pad2_ 3_and
U23  Net-_U23-Pad1_ Net-_U23-Pad2_ Net-_U23-Pad3_ d_nor
U32  Net-_U23-Pad3_ Net-_U1-Pad8_ Net-_U32-Pad3_ d_xor
U9  Net-_U10-Pad1_ Net-_U10-Pad2_ Net-_U34-Pad1_ d_nand
U34  Net-_U34-Pad1_ Net-_U1-Pad9_ Net-_U34-Pad3_ d_xor
X1  Net-_U15-Pad1_ Net-_U12-Pad1_ Net-_U10-Pad2_ Net-_U25-Pad1_ 3_and
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ Net-_U10-Pad3_ d_and
U25  Net-_U25-Pad1_ Net-_U10-Pad3_ Net-_U25-Pad3_ d_nor
U35  Net-_U25-Pad3_ Net-_U1-Pad10_ Net-_U35-Pad3_ d_xor
U11  Net-_U10-Pad1_ Net-_U10-Pad2_ Net-_U11-Pad3_ d_and
U12  Net-_U12-Pad1_ Net-_U10-Pad2_ Net-_U12-Pad3_ d_and
U26  Net-_U11-Pad3_ Net-_U12-Pad3_ Net-_U26-Pad3_ d_nor
U36  Net-_U26-Pad3_ Net-_U1-Pad15_ Net-_U36-Pad3_ d_xor
U13  Net-_U12-Pad1_ Net-_U10-Pad2_ Net-_U13-Pad3_ d_and
U14  Net-_U10-Pad1_ Net-_U10-Pad2_ Net-_U14-Pad3_ d_and
U15  Net-_U15-Pad1_ Net-_U10-Pad2_ Net-_U15-Pad3_ d_and
U27  Net-_U13-Pad3_ Net-_U14-Pad3_ Net-_U27-Pad3_ d_or
U28  Net-_U27-Pad3_ Net-_U15-Pad3_ Net-_U28-Pad3_ d_or
U33  Net-_U28-Pad3_ Net-_U33-Pad2_ d_inverter
U37  Net-_U33-Pad2_ Net-_U1-Pad16_ Net-_U37-Pad3_ d_xor
U8  Net-_U10-Pad2_ Net-_U41-Pad1_ d_inverter
U41  Net-_U41-Pad1_ Net-_U1-Pad17_ Net-_U41-Pad3_ d_xor
U16  Net-_U12-Pad1_ Net-_U15-Pad1_ Net-_U16-Pad3_ d_and
U24  Net-_U10-Pad2_ Net-_U16-Pad3_ Net-_U24-Pad3_ d_nor
U39  Net-_U24-Pad3_ Net-_U1-Pad11_ Net-_U39-Pad3_ d_xor
U20  Net-_U10-Pad2_ Net-_U12-Pad1_ Net-_U20-Pad3_ d_nor
U40  Net-_U20-Pad3_ Net-_U1-Pad12_ Net-_U40-Pad3_ d_xor
U17  Net-_U10-Pad2_ Net-_U12-Pad1_ Net-_U17-Pad3_ d_or
U18  Net-_U17-Pad3_ Net-_U15-Pad1_ Net-_U18-Pad3_ d_or
U29  Net-_U18-Pad3_ Net-_U29-Pad2_ d_inverter
U42  Net-_U29-Pad2_ Net-_U1-Pad13_ Net-_U42-Pad3_ d_xor
U19  Net-_U10-Pad2_ Net-_U10-Pad1_ Net-_U19-Pad3_ d_nor
U38  Net-_U19-Pad3_ Net-_U1-Pad14_ Net-_U38-Pad3_ d_xor
X6  Net-_U30-Pad3_ Net-_U31-Pad3_ Net-_U32-Pad3_ Net-_U43-Pad1_ 3_and
X7  Net-_U34-Pad3_ Net-_U35-Pad3_ Net-_U36-Pad3_ Net-_U43-Pad2_ 3_and
X8  Net-_U37-Pad3_ Net-_U41-Pad3_ Net-_U39-Pad3_ Net-_U44-Pad1_ 3_and
X9  Net-_U40-Pad3_ Net-_U42-Pad3_ Net-_U38-Pad3_ Net-_U44-Pad2_ 3_and
U43  Net-_U43-Pad1_ Net-_U43-Pad2_ Net-_U43-Pad3_ d_and
U44  Net-_U44-Pad1_ Net-_U44-Pad2_ Net-_U44-Pad3_ d_and
U45  Net-_U43-Pad3_ Net-_U44-Pad3_ Net-_U45-Pad3_ d_and
U46  Net-_U45-Pad3_ Net-_U46-Pad2_ Net-_U46-Pad3_ d_and
U47  Net-_U46-Pad3_ Net-_U1-Pad20_ d_inverter
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ ? Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ Net-_U1-Pad16_ Net-_U1-Pad17_ GNDPWR GNDPWR Net-_U1-Pad20_ PORT

.end
