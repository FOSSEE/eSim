.title KiCad schematic
Q6 Net-_D2-Pad2_ Net-_Q6-Pad2_ Net-_Q4-Pad2_ eSim_NPN
Q11 Net-_Q11-Pad1_ Net-_D1-Pad2_ Net-_Q11-Pad3_ eSim_NPN
Q8 Net-_Q12-Pad1_ Net-_D2-Pad2_ Net-_Q11-Pad3_ eSim_NPN
Q12 Net-_Q12-Pad1_ Net-_D1-Pad2_ Net-_Q12-Pad3_ eSim_NPN
Q10 Net-_Q10-Pad1_ Net-_D4-Pad1_ Net-_Q10-Pad3_ eSim_NPN
R9 Net-_Q13-Pad3_ Net-_R2-Pad2_ 500
Q13 Net-_Q13-Pad1_ Net-_D4-Pad1_ Net-_Q13-Pad3_ eSim_NPN
R8 Net-_Q10-Pad3_ Net-_R2-Pad2_ 500
Q7 Net-_Q11-Pad3_ Net-_Q7-Pad2_ Net-_Q7-Pad3_ eSim_NPN
Q14 Net-_Q12-Pad3_ Net-_Q14-Pad2_ Net-_Q13-Pad1_ eSim_NPN
Q9 Net-_Q11-Pad3_ Net-_Q7-Pad3_ Net-_Q10-Pad1_ eSim_NPN
Q16 Net-_Q12-Pad3_ Net-_Q16-Pad2_ Net-_Q14-Pad2_ eSim_NPN
Q15 Net-_Q11-Pad1_ Net-_D2-Pad2_ Net-_Q12-Pad3_ eSim_NPN
U1 Net-_D1-Pad1_ Net-_Q11-Pad1_ Net-_D3-Pad1_ Net-_Q1-Pad2_ Net-_Q2-Pad3_ Net-_Q4-Pad3_ Net-_R2-Pad2_ Net-_Q6-Pad2_ Net-_Q7-Pad2_ Net-_Q10-Pad1_ Net-_Q13-Pad1_ Net-_Q16-Pad2_ Net-_D4-Pad1_ Net-_Q12-Pad1_ PORT
R10 Net-_Q14-Pad2_ Net-_Q13-Pad1_ 4k
R6 Net-_D4-Pad2_ Net-_R2-Pad2_ 500
D4 Net-_D4-Pad1_ Net-_D4-Pad2_ eSim_Diode
D3 Net-_D3-Pad1_ Net-_D3-Pad2_ eSim_Diode
R4 Net-_Q4-Pad2_ Net-_Q4-Pad3_ 4k
R7 Net-_Q7-Pad3_ Net-_Q10-Pad1_ 4k
R5 Net-_D3-Pad2_ Net-_R2-Pad2_ 500
R1 Net-_Q1-Pad3_ Net-_Q2-Pad3_ 4k
Q1 Net-_D1-Pad2_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
D2 Net-_D1-Pad1_ Net-_D2-Pad2_ eSim_Diode
D1 Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
R2 Net-_Q3-Pad3_ Net-_R2-Pad2_ 500
Q3 Net-_Q2-Pad3_ Net-_D3-Pad1_ Net-_Q3-Pad3_ eSim_NPN
Q4 Net-_D2-Pad2_ Net-_Q4-Pad2_ Net-_Q4-Pad3_ eSim_NPN
Q2 Net-_D1-Pad2_ Net-_Q1-Pad3_ Net-_Q2-Pad3_ eSim_NPN
R3 Net-_Q5-Pad3_ Net-_R2-Pad2_ 500
Q5 Net-_Q4-Pad3_ Net-_D3-Pad1_ Net-_Q5-Pad3_ eSim_NPN
.end
