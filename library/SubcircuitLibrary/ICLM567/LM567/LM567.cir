.title KiCad schematic
U1 Net-_Q54-Pad2_ Net-_Q30-Pad1_ Net-_Q32-Pad2_ V+ A Net-_Q9-Pad2_ GND Net-_Q61-Pad1_ PORT
R3 Net-_Q6-Pad3_ V+ 47K
Q1 V+ Net-_Q1-Pad2_ A eSim_NPN
Q4 V+ Net-_Q4-Pad2_ A eSim_NPN
R1 Net-_Q1-Pad2_ V+ 47K
R2 Net-_Q4-Pad2_ Net-_Q2-Pad2_ 10K
Q6 Net-_Q2-Pad2_ D Net-_Q6-Pad3_ eSim_PNP
Q10 Net-_Q10-Pad1_ Net-_Q10-Pad2_ GND eSim_NPN
Q11 A A Net-_Q11-Pad3_ eSim_NPN
R4 Net-_Q12-Pad1_ Net-_Q11-Pad3_ 47K
Q12 Net-_Q12-Pad1_ Net-_Q12-Pad2_ GND eSim_NPN
R12 Net-_Q19-Pad3_ V+ 2.2K
Q19 GND Net-_Q16-Pad1_ Net-_Q19-Pad3_ eSim_PNP
R7 Net-_Q16-Pad1_ V+ 2.2K
Q16 Net-_Q16-Pad1_ Net-_Q10-Pad1_ Net-_Q16-Pad3_ eSim_NPN
Q20 Net-_Q16-Pad3_ B Net-_Q20-Pad3_ eSim_NPN
R10 GND Net-_Q20-Pad3_ 10K
Q22 Net-_Q22-Pad1_ Net-_Q22-Pad1_ Net-_Q16-Pad1_ eSim_NPN
R11 GND Net-_Q25-Pad3_ 2.2K
Q18 E Net-_Q10-Pad1_ Net-_Q18-Pad3_ eSim_NPN
Q5 Net-_Q2-Pad2_ Net-_Q12-Pad1_ GND eSim_NPN
Q3 Net-_Q1-Pad2_ Net-_Q2-Pad2_ GND eSim_NPN
Q7 Net-_Q2-Pad2_ Net-_Q2-Pad2_ Net-_Q10-Pad2_ eSim_NPN
Q8 Net-_Q10-Pad2_ Net-_Q10-Pad2_ GND eSim_NPN
Q2 A Net-_Q2-Pad2_ GND eSim_NPN
R5 Net-_Q13-Pad1_ V+ 22K
Q13 Net-_Q13-Pad1_ Net-_Q10-Pad1_ Net-_Q13-Pad3_ eSim_NPN
Q14 Net-_Q13-Pad3_ B Net-_Q14-Pad3_ eSim_NPN
Q9 V+ Net-_Q9-Pad2_ Net-_Q10-Pad1_ eSim_NPN
R6 GND Net-_Q14-Pad3_ 10K
R9 E Net-_R14-Pad1_ 10K
Q15 Net-_Q12-Pad2_ Net-_Q13-Pad1_ Net-_Q15-Pad3_ eSim_PNP
Q21 GND Net-_Q17-Pad3_ Net-_Q15-Pad3_ eSim_PNP
R8 Net-_Q15-Pad3_ V+ 22K
Q17 Net-_Q13-Pad1_ Net-_Q13-Pad1_ Net-_Q17-Pad3_ eSim_NPN
Q23 Net-_Q17-Pad3_ Net-_Q23-Pad2_ Net-_Q13-Pad3_ eSim_NPN
R13 Net-_Q17-Pad3_ V+ 22K
Q46 D D Net-_Q46-Pad3_ eSim_PNP
R36 Net-_Q42-Pad1_ Net-_Q34-Pad2_ 21K
R41 GND Net-_Q47-Pad3_ 2.2K
Q47 B B Net-_Q47-Pad3_ eSim_NPN
Q56 Net-_Q52-Pad3_ B Net-_Q56-Pad3_ eSim_NPN
R45 GND Net-_Q56-Pad3_ 10K
R40 B D 2.2K
Q58 Net-_Q57-Pad3_ Net-_Q32-Pad3_ Net-_Q52-Pad3_ eSim_NPN
Q52 Net-_Q51-Pad3_ Net-_Q38-Pad3_ Net-_Q52-Pad3_ eSim_NPN
R48 GND Net-_Q60-Pad3_ 4.7K
Q60 Net-_Q60-Pad1_ Net-_Q50-Pad1_ Net-_Q60-Pad3_ eSim_NPN
R47 Net-_Q60-Pad1_ V+ 4.7K
Q61 Net-_Q61-Pad1_ Net-_Q60-Pad3_ GND eSim_NPN
Q43 C C Net-_Q43-Pad3_ eSim_NPN
R30 Net-_Q33-Pad1_ Net-_Q38-Pad3_ 33K
Q42 Net-_Q42-Pad1_ Net-_Q42-Pad1_ C eSim_NPN
Q44 Net-_Q43-Pad3_ Net-_Q43-Pad3_ GND eSim_NPN
Q24 Net-_Q19-Pad3_ Net-_Q22-Pad1_ Net-_Q12-Pad1_ eSim_PNP
Q27 Net-_Q22-Pad1_ Net-_Q27-Pad2_ Net-_Q16-Pad3_ eSim_NPN
R20 GND Net-_Q27-Pad2_ 4.7K
R19 Net-_Q27-Pad2_ Net-_Q26-Pad2_ 4.7K
Q33 Net-_Q33-Pad1_ B Net-_Q33-Pad3_ eSim_NPN
R25 GND Net-_Q33-Pad3_ 4.7K
R23 A Net-_Q30-Pad2_ 4.7K
R27 Net-_Q30-Pad2_ Net-_Q34-Pad2_ 4.7K
Q32 Net-_Q30-Pad3_ Net-_Q32-Pad2_ Net-_Q32-Pad3_ eSim_NPN
R24 Net-_Q33-Pad1_ Net-_Q32-Pad3_ 33K
R16 Net-_Q22-Pad1_ V+ 2.2K
Q25 Net-_Q18-Pad3_ B Net-_Q25-Pad3_ eSim_NPN
Q26 F Net-_Q26-Pad2_ Net-_Q18-Pad3_ eSim_NPN
R33 Net-_Q38-Pad2_ Net-_Q42-Pad1_ 21K
R34 Net-_Q32-Pad2_ Net-_Q42-Pad1_ 21K
Q38 Net-_Q37-Pad3_ Net-_Q38-Pad2_ Net-_Q38-Pad3_ eSim_NPN
R31 Net-_Q35-Pad2_ V+ 47K
R28 Net-_Q36-Pad1_ Net-_Q35-Pad3_ 10K
R32 GND Net-_Q39-Pad3_ 10K
Q39 Net-_Q35-Pad2_ B Net-_Q39-Pad3_ eSim_NPN
Q31 V+ Net-_Q30-Pad1_ Net-_Q31-Pad3_ eSim_NPN
Q35 Net-_Q28-Pad1_ Net-_Q35-Pad2_ Net-_Q35-Pad3_ eSim_NPN
Q36 Net-_Q36-Pad1_ B Net-_Q36-Pad3_ eSim_NPN
R29 GND Net-_Q36-Pad3_ 10K
Q40 V+ Net-_Q30-Pad2_ Net-_Q37-Pad3_ eSim_NPN
Q37 Net-_Q30-Pad1_ Net-_Q34-Pad2_ Net-_Q37-Pad3_ eSim_NPN
R38 Net-_Q48-Pad3_ Net-_Q41-Pad3_ 21K
Q41 Net-_Q41-Pad1_ Net-_Q35-Pad2_ Net-_Q41-Pad3_ eSim_NPN
Q34 V+ Net-_Q34-Pad2_ Net-_Q30-Pad3_ eSim_NPN
R35 Net-_Q34-Pad2_ V+ 21K
R39 Net-_Q46-Pad3_ V+ 21K
R22 Net-_Q30-Pad1_ V+ 10K
R17 Net-_Q28-Pad1_ V+ 10K
Q30 Net-_Q30-Pad1_ Net-_Q30-Pad2_ Net-_Q30-Pad3_ eSim_NPN
R15 F Net-_R14-Pad1_ 10K
Q29 Net-_Q28-Pad3_ Net-_Q29-Pad2_ Net-_Q23-Pad2_ eSim_NPN
Q28 Net-_Q28-Pad1_ Net-_Q28-Pad1_ Net-_Q28-Pad3_ eSim_NPN
R26 Net-_Q36-Pad1_ Net-_Q31-Pad3_ 10K
R18 Net-_Q26-Pad2_ Net-_Q23-Pad2_ 10K
R21 Net-_Q29-Pad2_ Net-_Q28-Pad3_ 100K
R14 Net-_R14-Pad1_ V+ 10K
Q54 Net-_Q50-Pad3_ Net-_Q54-Pad2_ Net-_Q53-Pad2_ eSim_NPN
R46 Net-_Q54-Pad2_ V+ 4.7K
Q48 Net-_Q41-Pad1_ Net-_Q41-Pad3_ Net-_Q48-Pad3_ eSim_NPN
R44 Net-_Q48-Pad3_ Net-_Q53-Pad2_ 21K
Q53 Net-_Q50-Pad3_ Net-_Q53-Pad2_ Net-_Q48-Pad3_ eSim_NPN
R42 GND Net-_Q49-Pad3_ 10K
Q49 Net-_Q48-Pad3_ C Net-_Q49-Pad3_ eSim_NPN
Q57 V+ E Net-_Q57-Pad3_ eSim_NPN
Q59 Net-_Q54-Pad2_ F Net-_Q57-Pad3_ eSim_NPN
Q55 Net-_Q54-Pad2_ E Net-_Q51-Pad3_ eSim_NPN
Q51 V+ F Net-_Q51-Pad3_ eSim_NPN
Q45 Net-_Q41-Pad1_ Net-_Q41-Pad1_ Net-_Q45-Pad3_ eSim_PNP
R37 Net-_Q45-Pad3_ V+ 47K
R43 Net-_Q50-Pad3_ V+ 47K
Q50 Net-_Q50-Pad1_ Net-_Q41-Pad1_ Net-_Q50-Pad3_ eSim_PNP
.end
