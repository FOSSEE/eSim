* D:\FOSSEE\eSim\library\SubcircuitLibrary\SN74S350\SN74S350.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 07/06/25 16:22:32

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U45  Net-_U35-Pad3_ Net-_U36-Pad3_ Net-_U45-Pad3_ d_or
U50  Net-_U45-Pad3_ Net-_U46-Pad3_ Net-_U50-Pad3_ d_nor
U54  Net-_U50-Pad3_ Net-_U54-Pad2_ d_inverter
U58  Net-_U54-Pad2_ Net-_U55-Pad2_ /11 d_tristate
U6  /13 Net-_U55-Pad2_ d_inverter
U3  /10 Net-_U11-Pad1_ d_inverter
U4  Net-_U11-Pad1_ Net-_U10-Pad1_ d_inverter
U35  Net-_U19-Pad3_ /7 Net-_U35-Pad3_ d_and
U19  Net-_U11-Pad1_ Net-_U11-Pad2_ Net-_U19-Pad3_ d_and
U46  Net-_U37-Pad3_ Net-_U38-Pad3_ Net-_U46-Pad3_ d_or
U36  Net-_U20-Pad3_ /6 Net-_U36-Pad3_ d_and
U20  Net-_U10-Pad1_ Net-_U11-Pad2_ Net-_U20-Pad3_ d_and
U37  Net-_U21-Pad3_ /5 Net-_U37-Pad3_ d_and
U21  Net-_U11-Pad1_ Net-_U10-Pad2_ Net-_U21-Pad3_ d_and
U38  Net-_U22-Pad3_ /4 Net-_U38-Pad3_ d_and
U22  Net-_U10-Pad1_ Net-_U10-Pad2_ Net-_U22-Pad3_ d_and
U41  Net-_U27-Pad3_ Net-_U28-Pad3_ Net-_U41-Pad3_ d_or
U48  Net-_U41-Pad3_ Net-_U42-Pad3_ Net-_U48-Pad3_ d_nor
U52  Net-_U48-Pad3_ Net-_U52-Pad2_ d_inverter
U56  Net-_U52-Pad2_ Net-_U55-Pad2_ /12 d_tristate
U27  Net-_U11-Pad3_ /6 Net-_U27-Pad3_ d_and
U11  Net-_U11-Pad1_ Net-_U11-Pad2_ Net-_U11-Pad3_ d_and
U42  Net-_U29-Pad3_ Net-_U30-Pad3_ Net-_U42-Pad3_ d_or
U28  Net-_U12-Pad3_ /5 Net-_U28-Pad3_ d_and
U12  Net-_U10-Pad1_ Net-_U11-Pad2_ Net-_U12-Pad3_ d_and
U29  Net-_U13-Pad3_ /4 Net-_U29-Pad3_ d_and
U13  Net-_U11-Pad1_ Net-_U10-Pad2_ Net-_U13-Pad3_ d_and
U30  Net-_U14-Pad3_ /3 Net-_U30-Pad3_ d_and
U14  Net-_U10-Pad1_ Net-_U10-Pad2_ Net-_U14-Pad3_ d_and
U43  Net-_U31-Pad3_ Net-_U32-Pad3_ Net-_U43-Pad3_ d_or
U49  Net-_U43-Pad3_ Net-_U44-Pad3_ Net-_U49-Pad3_ d_nor
U53  Net-_U49-Pad3_ Net-_U53-Pad2_ d_inverter
U57  Net-_U53-Pad2_ Net-_U55-Pad2_ /14 d_tristate
U31  Net-_U15-Pad3_ /5 Net-_U31-Pad3_ d_and
U15  Net-_U11-Pad1_ Net-_U11-Pad2_ Net-_U15-Pad3_ d_and
U44  Net-_U33-Pad3_ Net-_U34-Pad3_ Net-_U44-Pad3_ d_or
U32  Net-_U16-Pad3_ /4 Net-_U32-Pad3_ d_and
U16  Net-_U10-Pad1_ Net-_U11-Pad2_ Net-_U16-Pad3_ d_and
U33  Net-_U17-Pad3_ /3 Net-_U33-Pad3_ d_and
U17  Net-_U11-Pad1_ Net-_U10-Pad2_ Net-_U17-Pad3_ d_and
U34  Net-_U18-Pad3_ /2 Net-_U34-Pad3_ d_and
U18  Net-_U10-Pad1_ Net-_U10-Pad2_ Net-_U18-Pad3_ d_and
U39  Net-_U23-Pad3_ Net-_U24-Pad3_ Net-_U39-Pad3_ d_or
U47  Net-_U39-Pad3_ Net-_U40-Pad3_ Net-_U47-Pad3_ d_nor
U51  Net-_U47-Pad3_ Net-_U51-Pad2_ d_inverter
U55  Net-_U51-Pad2_ Net-_U55-Pad2_ /15 d_tristate
U23  Net-_U23-Pad1_ /4 Net-_U23-Pad3_ d_and
U7  Net-_U11-Pad1_ Net-_U11-Pad2_ Net-_U23-Pad1_ d_and
U40  Net-_U25-Pad3_ Net-_U26-Pad3_ Net-_U40-Pad3_ d_or
U24  Net-_U24-Pad1_ /3 Net-_U24-Pad3_ d_and
U8  Net-_U10-Pad1_ Net-_U11-Pad2_ Net-_U24-Pad1_ d_and
U25  Net-_U25-Pad1_ /2 Net-_U25-Pad3_ d_and
U9  Net-_U11-Pad1_ Net-_U10-Pad2_ Net-_U25-Pad1_ d_and
U26  Net-_U10-Pad3_ /1 Net-_U26-Pad3_ d_and
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ Net-_U10-Pad3_ d_and
U2  /9 Net-_U11-Pad2_ d_inverter
U5  Net-_U11-Pad2_ Net-_U10-Pad2_ d_inverter
U1  /1 /2 /3 /4 /5 /6 /7 ? /9 /10 /11 /12 /13 /14 /15 ? PORT

.end
