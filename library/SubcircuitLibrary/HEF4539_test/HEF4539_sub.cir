.title KiCad schematic
U19 Net-_U1-Pad2_ Net-_U10-Pad1_ d_inverter
U20 Net-_U10-Pad1_ Net-_U15-Pad1_ d_inverter
U23 Net-_U13-Pad2_ Net-_U18-Pad2_ d_inverter
U22 Net-_U1-Pad14_ Net-_U13-Pad2_ d_inverter
U25 Net-_U1-Pad10_ Net-_U24-Pad1_ d_inverter
U27 Net-_U1-Pad11_ Net-_U27-Pad2_ d_inverter
U31 Net-_U1-Pad12_ Net-_U31-Pad2_ d_inverter
U21 Net-_U15-Pad1_ Net-_U18-Pad3_ Net-_U17-Pad1_ d_and
U26 Net-_U10-Pad1_ Net-_U24-Pad3_ Net-_U26-Pad3_ d_and
U24 Net-_U24-Pad1_ Net-_U13-Pad2_ Net-_U24-Pad3_ d_and
U18 Net-_U16-Pad2_ Net-_U18-Pad2_ Net-_U18-Pad3_ d_and
U13 Net-_U12-Pad2_ Net-_U13-Pad2_ Net-_U13-Pad3_ d_and
U1 Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ unconnected-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ unconnected-_U1-Pad16_ PORT
U14 Net-_U11-Pad3_ Net-_U1-Pad7_ d_inverter
U3 Net-_U3-Pad1_ Net-_U13-Pad2_ Net-_U3-Pad3_ d_and
U4 Net-_U10-Pad1_ Net-_U3-Pad3_ Net-_U4-Pad3_ d_and
U8 Net-_U8-Pad1_ Net-_U18-Pad2_ Net-_U10-Pad2_ d_and
U17 Net-_U17-Pad1_ Net-_U15-Pad3_ Net-_U11-Pad1_ d_nor
U15 Net-_U15-Pad1_ Net-_U13-Pad3_ Net-_U15-Pad3_ d_and
U10 Net-_U10-Pad1_ Net-_U10-Pad2_ Net-_U10-Pad3_ d_and
U7 Net-_U10-Pad3_ Net-_U4-Pad3_ Net-_U6-Pad1_ d_nor
U6 Net-_U6-Pad1_ Net-_U2-Pad2_ Net-_U11-Pad2_ d_and
U11 Net-_U11-Pad1_ Net-_U11-Pad2_ Net-_U11-Pad3_ d_nand
U16 Net-_U1-Pad3_ Net-_U16-Pad2_ d_inverter
U5 Net-_U1-Pad6_ Net-_U3-Pad1_ d_inverter
U2 Net-_U1-Pad1_ Net-_U2-Pad2_ d_inverter
U9 Net-_U1-Pad5_ Net-_U8-Pad1_ d_inverter
U12 Net-_U1-Pad4_ Net-_U12-Pad2_ d_inverter
U38 Net-_U38-Pad1_ Net-_U36-Pad3_ Net-_U38-Pad3_ d_nor
U36 Net-_U15-Pad1_ Net-_U32-Pad3_ Net-_U36-Pad3_ d_and
U30 Net-_U10-Pad1_ Net-_U28-Pad3_ Net-_U29-Pad1_ d_and
U29 Net-_U29-Pad1_ Net-_U26-Pad3_ Net-_U29-Pad3_ d_nor
U39 Net-_U39-Pad1_ Net-_U38-Pad3_ Net-_U33-Pad1_ d_and
U33 Net-_U33-Pad1_ Net-_U29-Pad3_ Net-_U33-Pad3_ d_nand
U34 Net-_U33-Pad3_ Net-_U1-Pad9_ d_inverter
U40 Net-_U15-Pad1_ Net-_U37-Pad3_ Net-_U38-Pad1_ d_and
U41 Net-_U1-Pad15_ Net-_U39-Pad1_ d_inverter
U35 Net-_U1-Pad13_ Net-_U35-Pad2_ d_inverter
U37 Net-_U35-Pad2_ Net-_U18-Pad2_ Net-_U37-Pad3_ d_and
U32 Net-_U31-Pad2_ Net-_U13-Pad2_ Net-_U32-Pad3_ d_and
U28 Net-_U27-Pad2_ Net-_U18-Pad2_ Net-_U28-Pad3_ d_and
.end
