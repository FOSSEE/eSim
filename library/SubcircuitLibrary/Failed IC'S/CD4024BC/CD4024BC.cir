* C:\FOSSEE\eSim\library\SubcircuitLibrary\CD4024BC\CD4024BC.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/19/25 23:21:47

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U2  Net-_U12-Pad3_ Net-_U2-Pad2_ Net-_U2-Pad3_ d_tristate
M2  Net-_M1-Pad3_ Net-_M2-Pad2_ Net-_M1-Pad1_ vdd eSim_MOS_P
M1  Net-_M1-Pad1_ Net-_M1-Pad2_ Net-_M1-Pad3_ gnd eSim_MOS_N
M4  Net-_M3-Pad3_ Net-_M2-Pad2_ Net-_M1-Pad3_ vdd eSim_MOS_P
M3  Net-_M1-Pad3_ Net-_M1-Pad2_ Net-_M3-Pad3_ gnd eSim_MOS_N
M5  Net-_M5-Pad1_ Net-_M2-Pad2_ Net-_M5-Pad3_ vdd eSim_MOS_P
M6  Net-_M5-Pad3_ Net-_M5-Pad3_ Net-_M5-Pad1_ gnd eSim_MOS_N
M8  Net-_M7-Pad3_ Net-_M5-Pad3_ Net-_M5-Pad3_ gnd eSim_MOS_N
M7  Net-_M5-Pad3_ Net-_M2-Pad2_ Net-_M7-Pad3_ vdd eSim_MOS_P
U3  Net-_U15-Pad1_ Net-_U22-Pad2_ Net-_U14-Pad1_ d_tristate
U4  Net-_U17-Pad2_ Net-_U22-Pad2_ Net-_U10-Pad1_ d_tristate
U1  vdd gnd Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_M1-Pad1_ Net-_U1-Pad7_ PORT
U7  Net-_U2-Pad3_ Net-_M1-Pad2_ d_inverter
U8  Net-_U5-Pad2_ Net-_U2-Pad2_ d_inverter
U5  Net-_U12-Pad4_ Net-_U5-Pad2_ d_inverter
U9  Net-_M1-Pad2_ Net-_U18-Pad1_ d_inverter
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ d_inverter
U11  Net-_U10-Pad1_ Net-_U11-Pad2_ d_inverter
U6  Net-_U13-Pad2_ Net-_U15-Pad1_ d_inverter
U18  Net-_U18-Pad1_ Net-_M2-Pad2_ dac_bridge_1
U19  Net-_M1-Pad2_ Net-_M5-Pad3_ dac_bridge_1
U14  Net-_U14-Pad1_ Net-_M3-Pad3_ dac_bridge_1
U13  Net-_M1-Pad3_ Net-_U13-Pad2_ adc_bridge_1
U15  Net-_U15-Pad1_ Net-_M5-Pad1_ dac_bridge_1
U17  Net-_M5-Pad3_ Net-_U17-Pad2_ adc_bridge_1
U16  Net-_U10-Pad2_ Net-_M7-Pad3_ dac_bridge_1
U21  Net-_U11-Pad2_ Net-_U1-Pad5_ dac_bridge_1
U12  Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U12-Pad3_ Net-_U12-Pad4_ adc_bridge_2
U20  Net-_U10-Pad1_ Net-_U1-Pad7_ adc_bridge_1
U22  Net-_U2-Pad2_ Net-_U22-Pad2_ dac_bridge_1

.end
