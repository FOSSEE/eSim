* C:\FOSSEE\eSim\library\SubcircuitLibrary\CD4724BC\CD4724BC.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/19/25 16:51:05

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U11  Net-_U1-Pad4_ Net-_U11-Pad2_ d_inverter
U18  Net-_U11-Pad2_ Net-_U18-Pad2_ d_inverter
U12  Net-_U1-Pad5_ Net-_U12-Pad2_ d_inverter
U19  Net-_U12-Pad2_ Net-_U1-Pad6_ Net-_U19-Pad3_ d_nand
U20  Net-_U19-Pad3_ Net-_U12-Pad2_ Net-_U20-Pad3_ d_nand
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ PORT
U58  Net-_U31-Pad3_ Net-_U32-Pad3_ Net-_U39-Pad1_ d_nand
U32  Net-_U18-Pad2_ Net-_U32-Pad2_ Net-_U32-Pad3_ d_or
U31  Net-_U19-Pad3_ Net-_U31-Pad2_ Net-_U31-Pad3_ d_or
U39  Net-_U39-Pad1_ Net-_U39-Pad2_ d_buffer
U62  Net-_U39-Pad2_ Net-_U42-Pad3_ Net-_U62-Pad3_ d_nand
U42  Net-_U31-Pad2_ Net-_U20-Pad3_ Net-_U42-Pad3_ d_or
U72  Net-_U62-Pad3_ Net-_U1-Pad7_ d_inverter
U59  Net-_U33-Pad3_ Net-_U34-Pad3_ Net-_U40-Pad1_ d_nand
U34  Net-_U18-Pad2_ Net-_U34-Pad2_ Net-_U34-Pad3_ d_or
U33  Net-_U19-Pad3_ Net-_U33-Pad2_ Net-_U33-Pad3_ d_or
U40  Net-_U40-Pad1_ Net-_U40-Pad2_ d_buffer
U63  Net-_U40-Pad2_ Net-_U43-Pad3_ Net-_U100-Pad1_ d_nand
U43  Net-_U33-Pad2_ Net-_U20-Pad3_ Net-_U43-Pad3_ d_or
U73  Net-_U100-Pad1_ Net-_U1-Pad8_ d_inverter
U56  Net-_U27-Pad3_ Net-_U28-Pad3_ Net-_U30-Pad1_ d_nand
U28  Net-_U18-Pad2_ Net-_U28-Pad2_ Net-_U28-Pad3_ d_or
U27  Net-_U19-Pad3_ Net-_U10-Pad2_ Net-_U27-Pad3_ d_or
U30  Net-_U30-Pad1_ Net-_U30-Pad2_ d_buffer
U60  Net-_U30-Pad2_ Net-_U36-Pad3_ Net-_U60-Pad3_ d_nand
U36  Net-_U10-Pad2_ Net-_U20-Pad3_ Net-_U36-Pad3_ d_or
U71  Net-_U60-Pad3_ Net-_U1-Pad9_ d_inverter
U53  Net-_U21-Pad3_ Net-_U22-Pad3_ Net-_U23-Pad1_ d_nand
U22  Net-_U18-Pad2_ Net-_U22-Pad2_ Net-_U22-Pad3_ d_or
U21  Net-_U19-Pad3_ Net-_U13-Pad2_ Net-_U21-Pad3_ d_or
U23  Net-_U23-Pad1_ Net-_U23-Pad2_ d_buffer
U54  Net-_U23-Pad2_ Net-_U24-Pad3_ Net-_U54-Pad3_ d_nand
U24  Net-_U13-Pad2_ Net-_U20-Pad3_ Net-_U24-Pad3_ d_or
U69  Net-_U54-Pad3_ Net-_U1-Pad10_ d_inverter
U55  Net-_U25-Pad3_ Net-_U26-Pad3_ Net-_U29-Pad1_ d_nand
U26  Net-_U18-Pad2_ Net-_U26-Pad2_ Net-_U26-Pad3_ d_or
U25  Net-_U19-Pad3_ Net-_U14-Pad2_ Net-_U25-Pad3_ d_or
U29  Net-_U29-Pad1_ Net-_U29-Pad2_ d_buffer
U57  Net-_U29-Pad2_ Net-_U35-Pad3_ Net-_U57-Pad3_ d_nand
U35  Net-_U14-Pad2_ Net-_U20-Pad3_ Net-_U35-Pad3_ d_or
U70  Net-_U57-Pad3_ Net-_U1-Pad11_ d_inverter
U61  Net-_U37-Pad3_ Net-_U38-Pad3_ Net-_U41-Pad1_ d_nand
U38  Net-_U18-Pad2_ Net-_U38-Pad2_ Net-_U38-Pad3_ d_or
U37  Net-_U19-Pad3_ Net-_U15-Pad2_ Net-_U37-Pad3_ d_or
U41  Net-_U41-Pad1_ Net-_U41-Pad2_ d_buffer
U64  Net-_U41-Pad2_ Net-_U44-Pad3_ Net-_U64-Pad3_ d_nand
U44  Net-_U15-Pad2_ Net-_U20-Pad3_ Net-_U44-Pad3_ d_or
U74  Net-_U64-Pad3_ Net-_U1-Pad12_ d_inverter
U65  Net-_U45-Pad3_ Net-_U46-Pad3_ Net-_U47-Pad1_ d_nand
U46  Net-_U18-Pad2_ Net-_U46-Pad2_ Net-_U46-Pad3_ d_or
U45  Net-_U19-Pad3_ Net-_U16-Pad2_ Net-_U45-Pad3_ d_or
U47  Net-_U47-Pad1_ Net-_U47-Pad2_ d_buffer
U66  Net-_U47-Pad2_ Net-_U48-Pad3_ Net-_U66-Pad3_ d_nand
U48  Net-_U16-Pad2_ Net-_U20-Pad3_ Net-_U48-Pad3_ d_or
U75  Net-_U66-Pad3_ Net-_U1-Pad13_ d_inverter
U67  Net-_U49-Pad3_ Net-_U50-Pad3_ Net-_U51-Pad1_ d_nand
U50  Net-_U18-Pad2_ Net-_U50-Pad2_ Net-_U50-Pad3_ d_or
U49  Net-_U19-Pad3_ Net-_U17-Pad2_ Net-_U49-Pad3_ d_or
U51  Net-_U51-Pad1_ Net-_U51-Pad2_ d_buffer
U68  Net-_U51-Pad2_ Net-_U52-Pad3_ Net-_U68-Pad3_ d_nand
U52  Net-_U17-Pad2_ Net-_U20-Pad3_ Net-_U52-Pad3_ d_or
U76  Net-_U68-Pad3_ Net-_U1-Pad14_ d_inverter
U2  Net-_U1-Pad1_ Net-_U2-Pad2_ d_inverter
U3  Net-_U2-Pad2_ Net-_U3-Pad2_ d_inverter
U4  Net-_U1-Pad2_ Net-_U4-Pad2_ d_inverter
U5  Net-_U4-Pad2_ Net-_U5-Pad2_ d_inverter
U6  Net-_U1-Pad3_ Net-_U6-Pad2_ d_inverter
U7  Net-_U6-Pad2_ Net-_U7-Pad2_ d_inverter
X1  Net-_U6-Pad2_ Net-_U4-Pad2_ Net-_U2-Pad2_ Net-_U8-Pad1_ 3_and
X2  Net-_U7-Pad2_ Net-_U4-Pad2_ Net-_U2-Pad2_ Net-_U9-Pad1_ 3_and
X3  Net-_U6-Pad2_ Net-_U5-Pad2_ Net-_U2-Pad2_ Net-_U10-Pad1_ 3_and
X4  Net-_U7-Pad2_ Net-_U5-Pad2_ Net-_U2-Pad2_ Net-_U13-Pad1_ 3_and
X5  Net-_U6-Pad2_ Net-_U4-Pad2_ Net-_U3-Pad2_ Net-_U14-Pad1_ 3_and
X6  Net-_U7-Pad2_ Net-_U4-Pad2_ Net-_U3-Pad2_ Net-_U15-Pad1_ 3_and
X7  Net-_U6-Pad2_ Net-_U5-Pad2_ Net-_U3-Pad2_ Net-_U16-Pad1_ 3_and
X8  Net-_U7-Pad2_ Net-_U5-Pad2_ Net-_U3-Pad2_ Net-_U17-Pad1_ 3_and
U8  Net-_U8-Pad1_ Net-_U31-Pad2_ d_inverter
U9  Net-_U9-Pad1_ Net-_U33-Pad2_ d_inverter
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ d_inverter
U13  Net-_U13-Pad1_ Net-_U13-Pad2_ d_inverter
U14  Net-_U14-Pad1_ Net-_U14-Pad2_ d_inverter
U15  Net-_U15-Pad1_ Net-_U15-Pad2_ d_inverter
U16  Net-_U16-Pad1_ Net-_U16-Pad2_ d_inverter
U17  Net-_U17-Pad1_ Net-_U17-Pad2_ d_inverter
U81  Net-_U39-Pad1_ IC
U86  Net-_U40-Pad1_ IC
U82  Net-_U30-Pad1_ IC
U77  Net-_U23-Pad1_ IC
U79  Net-_U29-Pad1_ IC
U84  Net-_U41-Pad1_ IC
U89  Net-_U47-Pad1_ IC
U90  Net-_U51-Pad1_ IC
U80  Net-_U62-Pad3_ Net-_U32-Pad2_ d_buffer
U98  Net-_U100-Pad1_ Net-_U34-Pad2_ d_buffer
U83  Net-_U60-Pad3_ Net-_U28-Pad2_ d_buffer
U78  Net-_U54-Pad3_ Net-_U22-Pad2_ d_buffer
U85  Net-_U57-Pad3_ Net-_U26-Pad2_ d_buffer
U87  Net-_U64-Pad3_ Net-_U38-Pad2_ d_buffer
U91  Net-_U66-Pad3_ Net-_U46-Pad2_ d_buffer
U96  Net-_U68-Pad3_ Net-_U50-Pad2_ d_buffer
U99  Net-_U68-Pad3_ IC
U97  Net-_U66-Pad3_ IC
U95  Net-_U64-Pad3_ IC
U92  Net-_U57-Pad3_ IC
U88  Net-_U54-Pad3_ IC
U93  Net-_U60-Pad3_ IC
U100  Net-_U100-Pad1_ IC
U94  Net-_U62-Pad3_ IC

.end
