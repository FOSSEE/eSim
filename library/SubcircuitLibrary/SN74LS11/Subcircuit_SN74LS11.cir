* C:\FOSSEE\eSim\library\SubcircuitLibrary\Subcircuit_SN74LS11\Subcircuit_SN74LS11.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 02/10/25 19:11:48

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
R1  Net-_R1-Pad1_ Net-_Q1-Pad2_ 20k
R2  Net-_R1-Pad1_ Net-_Q1-Pad1_ 10k
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_D1-Pad1_ eSim_NPN
Q2  Net-_Q2-Pad1_ Net-_Q1-Pad1_ Net-_C1-Pad1_ eSim_NPN
Q4  Net-_Q4-Pad1_ Net-_Q2-Pad1_ Net-_Q4-Pad3_ eSim_NPN
R4  Net-_R1-Pad1_ Net-_Q2-Pad1_ 8k
R7  Net-_R1-Pad1_ Net-_Q4-Pad1_ 120
U2  GNDPWR Net-_U1-Pad1_ zener
U3  GNDPWR Net-_U1-Pad2_ zener
U4  GNDPWR Net-_U1-Pad3_ zener
U7  Net-_Q1-Pad2_ Net-_U1-Pad3_ zener
U6  Net-_Q1-Pad2_ Net-_U1-Pad2_ zener
D1  Net-_D1-Pad1_ GNDPWR eSim_Diode
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 10pF
R3  Net-_C1-Pad1_ Net-_Q3-Pad2_ 1.5k
R5  Net-_C1-Pad1_ Net-_Q3-Pad1_ 3k
Q3  Net-_Q3-Pad1_ Net-_Q3-Pad2_ GNDPWR eSim_NPN
Q6  Net-_C1-Pad2_ Net-_C1-Pad1_ GNDPWR eSim_NPN
U9  Net-_R6-Pad2_ Net-_Q2-Pad1_ zener
R6  Net-_C1-Pad2_ Net-_R6-Pad2_ 5k
Q5  Net-_Q4-Pad1_ Net-_Q4-Pad3_ Net-_C1-Pad2_ eSim_NPN
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_C1-Pad2_ Net-_R1-Pad1_ GNDPWR Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_C2-Pad2_ Net-_C3-Pad2_ PORT
U5  Net-_Q1-Pad2_ Net-_U1-Pad1_ zener
R15  Net-_R1-Pad1_ Net-_Q13-Pad2_ 20k
R16  Net-_R1-Pad1_ Net-_Q13-Pad1_ 10k
Q13  Net-_Q13-Pad1_ Net-_Q13-Pad2_ Net-_D3-Pad1_ eSim_NPN
Q14  Net-_Q14-Pad1_ Net-_Q13-Pad1_ Net-_C3-Pad1_ eSim_NPN
Q16  Net-_Q16-Pad1_ Net-_Q14-Pad1_ Net-_Q16-Pad3_ eSim_NPN
R18  Net-_R1-Pad1_ Net-_Q14-Pad1_ 8k
R21  Net-_R1-Pad1_ Net-_Q16-Pad1_ 120
U16  GNDPWR Net-_U1-Pad10_ zener
U17  GNDPWR Net-_U1-Pad11_ zener
U18  GNDPWR Net-_U1-Pad12_ zener
U21  Net-_Q13-Pad2_ Net-_U1-Pad12_ zener
U20  Net-_Q13-Pad2_ Net-_U1-Pad11_ zener
D3  Net-_D3-Pad1_ GNDPWR eSim_Diode
C3  Net-_C3-Pad1_ Net-_C3-Pad2_ 10pF
R17  Net-_C3-Pad1_ Net-_Q15-Pad2_ 1.5k
R19  Net-_C3-Pad1_ Net-_Q15-Pad1_ 3k
Q15  Net-_Q15-Pad1_ Net-_Q15-Pad2_ GNDPWR eSim_NPN
Q18  Net-_C3-Pad2_ Net-_C3-Pad1_ GNDPWR eSim_NPN
U22  Net-_R20-Pad2_ Net-_Q14-Pad1_ zener
R20  Net-_C3-Pad2_ Net-_R20-Pad2_ 5k
Q17  Net-_Q16-Pad1_ Net-_Q16-Pad3_ Net-_C3-Pad2_ eSim_NPN
U19  Net-_Q13-Pad2_ Net-_U1-Pad10_ zener
R8  Net-_R1-Pad1_ Net-_Q7-Pad2_ 20k
R9  Net-_R1-Pad1_ Net-_Q7-Pad1_ 10k
Q7  Net-_Q7-Pad1_ Net-_Q7-Pad2_ Net-_D2-Pad1_ eSim_NPN
Q8  Net-_Q10-Pad2_ Net-_Q7-Pad1_ Net-_C2-Pad1_ eSim_NPN
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
R11  Net-_R1-Pad1_ Net-_Q10-Pad2_ 8k
R14  Net-_R1-Pad1_ Net-_Q10-Pad1_ 120
U8  GNDPWR Net-_U1-Pad4_ zener
U10  GNDPWR Net-_U1-Pad5_ zener
U11  GNDPWR Net-_U1-Pad6_ zener
U14  Net-_Q7-Pad2_ Net-_U1-Pad6_ zener
U13  Net-_Q7-Pad2_ Net-_U1-Pad5_ zener
D2  Net-_D2-Pad1_ GNDPWR eSim_Diode
C2  Net-_C2-Pad1_ Net-_C2-Pad2_ 10pF
R10  Net-_C2-Pad1_ Net-_Q9-Pad2_ 1.5k
R12  Net-_C2-Pad1_ Net-_Q9-Pad1_ 3k
Q9  Net-_Q9-Pad1_ Net-_Q9-Pad2_ GNDPWR eSim_NPN
Q12  Net-_C2-Pad2_ Net-_C2-Pad1_ GNDPWR eSim_NPN
U15  Net-_R13-Pad2_ Net-_Q10-Pad2_ zener
R13  Net-_C2-Pad2_ Net-_R13-Pad2_ 5k
Q11  Net-_Q10-Pad1_ Net-_Q10-Pad3_ Net-_C2-Pad2_ eSim_NPN
U12  Net-_Q7-Pad2_ Net-_U1-Pad4_ zener

.end
