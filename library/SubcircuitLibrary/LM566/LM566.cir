.title KiCad schematic
R5 Net-_Q18-Pad2_ Net-_Q1-Pad1_ 14k
R8 Net-_Q19-Pad3_ Net-_Q21-Pad3_ 8400
Q23 Net-_Q22-Pad1_ Net-_Q21-Pad3_ Net-_Q19-Pad3_ eSim_NPN
R10 Net-_Q13-Pad3_ Net-_Q19-Pad3_ 2.6k
Q19 Net-_Q19-Pad1_ Net-_Q17-Pad3_ Net-_Q19-Pad3_ eSim_NPN
U1 Net-_Q13-Pad3_ unconnected-_U1-Pad2_ Net-_Q24-Pad3_ Net-_Q1-Pad3_ Net-_Q3-Pad3_ Net-_Q5-Pad1_ Net-_Q10-Pad1_ Net-_Q1-Pad1_ PORT
Q8 Net-_Q3-Pad2_ Net-_Q3-Pad2_ Net-_Q5-Pad1_ eSim_PNP
Q5 Net-_Q5-Pad1_ Net-_Q3-Pad3_ Net-_Q3-Pad2_ eSim_NPN
Q9 Net-_Q3-Pad2_ Net-_Q3-Pad2_ Net-_Q10-Pad3_ eSim_NPN
Q6 Net-_Q3-Pad2_ Net-_Q3-Pad2_ Net-_Q10-Pad3_ eSim_NPN
R13 Net-_Q26-Pad3_ Net-_Q1-Pad1_ 16k
Q29 unconnected-_Q29-Pad1_ Net-_Q28-Pad2_ Net-_Q1-Pad1_ eSim_NPN
R14 Net-_Q14-Pad3_ Net-_Q27-Pad2_ 5800
Q24 Net-_Q1-Pad1_ Net-_Q22-Pad1_ Net-_Q24-Pad3_ eSim_NPN
R15 Net-_Q28-Pad2_ Net-_Q1-Pad1_ 4300
Q28 Net-_Q27-Pad2_ Net-_Q28-Pad2_ Net-_Q26-Pad3_ eSim_PNP
Q27 Net-_Q26-Pad3_ Net-_Q27-Pad2_ Net-_Q14-Pad3_ eSim_NPN
Q26 Net-_Q13-Pad3_ Net-_Q24-Pad3_ Net-_Q26-Pad3_ eSim_PNP
Q12 Net-_Q11-Pad3_ Net-_Q11-Pad3_ Net-_Q12-Pad3_ eSim_NPN
R3 Net-_Q13-Pad1_ Net-_Q12-Pad3_ 530
Q14 Net-_Q13-Pad1_ Net-_Q13-Pad1_ Net-_Q14-Pad3_ eSim_PNP
Q13 Net-_Q13-Pad1_ Net-_Q13-Pad2_ Net-_Q13-Pad3_ eSim_NPN
Q18 Net-_Q1-Pad2_ Net-_Q18-Pad2_ Net-_Q18-Pad3_ eSim_NPN
R4 Net-_Q13-Pad3_ Net-_Q13-Pad2_ 7000
R6 Net-_Q13-Pad3_ Net-_Q18-Pad3_ 2400
Q15 Net-_Q14-Pad3_ Net-_Q14-Pad3_ Net-_Q13-Pad2_ eSim_NPN
Q4 Net-_Q10-Pad3_ Net-_Q10-Pad3_ Net-_Q11-Pad2_ eSim_NPN
Q10 Net-_Q10-Pad1_ Net-_Q10-Pad1_ Net-_Q10-Pad3_ eSim_PNP
Q11 Net-_Q10-Pad1_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_NPN
Q1 Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
Q3 unconnected-_Q3-Pad1_ Net-_Q3-Pad2_ Net-_Q3-Pad3_ eSim_NPN
Q16 Net-_Q1-Pad1_ Net-_Q10-Pad1_ Net-_Q1-Pad2_ eSim_NPN
Q22 Net-_Q22-Pad1_ Net-_Q22-Pad1_ Net-_Q19-Pad1_ eSim_PNP
R9 Net-_Q22-Pad1_ Net-_Q1-Pad1_ 4700
Q17 unconnected-_Q17-Pad1_ Net-_Q1-Pad2_ Net-_Q17-Pad3_ eSim_NPN
Q21 unconnected-_Q21-Pad1_ Net-_Q19-Pad1_ Net-_Q21-Pad3_ eSim_NPN
R7 Net-_Q19-Pad1_ Net-_Q1-Pad1_ 6500
Q20 Net-_Q19-Pad1_ Net-_Q19-Pad1_ Net-_Q1-Pad2_ eSim_PNP
Q2 Net-_Q1-Pad3_ Net-_Q18-Pad2_ Net-_Q2-Pad3_ eSim_NPN
R1 Net-_Q13-Pad3_ Net-_Q2-Pad3_ 200
R2 Net-_Q13-Pad1_ Net-_Q7-Pad3_ 530
Q7 Net-_Q11-Pad2_ Net-_Q11-Pad3_ Net-_Q7-Pad3_ eSim_NPN
R11 Net-_Q13-Pad3_ Net-_Q25-Pad3_ 200
Q25 Net-_Q18-Pad2_ Net-_Q18-Pad2_ Net-_Q25-Pad3_ eSim_NPN
Q30 Net-_Q28-Pad2_ Net-_Q18-Pad2_ Net-_Q30-Pad3_ eSim_NPN
R12 Net-_Q13-Pad3_ Net-_Q24-Pad3_ 4800
R16 Net-_Q13-Pad3_ Net-_Q30-Pad3_ 200
.end
