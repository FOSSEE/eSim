* C:\Users\Public\Music\FOSSEE\eSim\library\SubcircuitLibrary\DM74LS460\DM74LS460.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 05/17/25 16:37:47

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U2  Net-_U1-Pad20_ Net-_U1-Pad21_ Net-_U2-Pad3_ d_xnor
U3  Net-_U1-Pad22_ Net-_U1-Pad23_ Net-_U3-Pad3_ d_xnor
U8  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U8-Pad3_ d_xnor
U9  Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U9-Pad3_ d_xnor
U4  Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U4-Pad3_ d_xnor
U5  Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U5-Pad3_ d_xnor
U10  Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U10-Pad3_ d_xnor
U11  Net-_U1-Pad11_ Net-_U1-Pad13_ Net-_U11-Pad3_ d_xnor
U6  Net-_U1-Pad14_ Net-_U1-Pad15_ Net-_U12-Pad1_ d_xnor
U7  Net-_U1-Pad16_ Net-_U1-Pad17_ Net-_U12-Pad2_ d_xnor
X1  Net-_U2-Pad3_ Net-_U3-Pad3_ Net-_U8-Pad3_ Net-_U9-Pad3_ Net-_X1-Pad5_ 4_and
X2  Net-_U4-Pad3_ Net-_U5-Pad3_ Net-_U10-Pad3_ Net-_U11-Pad3_ Net-_X2-Pad5_ 4_and
U12  Net-_U12-Pad1_ Net-_U12-Pad2_ Net-_U12-Pad3_ d_and
X3  Net-_X1-Pad5_ Net-_X2-Pad5_ Net-_U12-Pad3_ Net-_U13-Pad1_ 3_and
U14  Net-_U13-Pad1_ Net-_U1-Pad18_ d_buffer
U13  Net-_U13-Pad1_ Net-_U1-Pad19_ d_inverter
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ ? Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ Net-_U1-Pad16_ Net-_U1-Pad17_ Net-_U1-Pad18_ Net-_U1-Pad19_ Net-_U1-Pad20_ Net-_U1-Pad21_ Net-_U1-Pad22_ Net-_U1-Pad23_ ? PORT

.end
