.title KiCad schematic
X5 Net-_U2-Pad2_ Net-_U8-Pad2_ Net-_U7-Pad2_ Net-_U5-Pad2_ Net-_U1-Pad1_ Net-_X3-Pad1_ 5_and
X7 Net-_U2-Pad2_ Net-_U6-Pad2_ Net-_U8-Pad2_ Net-_U4-Pad2_ Net-_U1-Pad14_ Net-_X7-Pad6_ 5_and
X6 Net-_U2-Pad2_ Net-_U3-Pad2_ Net-_U6-Pad2_ Net-_U4-Pad2_ Net-_U1-Pad15_ Net-_X6-Pad6_ 5_and
U14 Net-_U14-Pad1_ Net-_U14-Pad2_ Net-_U14-Pad3_ d_or
X8 Net-_X10-Pad6_ Net-_X8-Pad2_ Net-_X7-Pad6_ Net-_X6-Pad6_ Net-_U14-Pad1_ 4_OR
U10 Net-_U14-Pad3_ Net-_U10-Pad2_ d_inverter
U1 Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ GND Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ GND PORT
X4 Net-_U2-Pad2_ Net-_U3-Pad2_ Net-_U7-Pad2_ Net-_U5-Pad2_ Net-_U1-Pad2_ Net-_X3-Pad2_ 5_and
X3 Net-_X3-Pad1_ Net-_X3-Pad2_ Net-_X2-Pad6_ Net-_X1-Pad6_ Net-_U14-Pad2_ 4_OR
U13 Net-_U10-Pad2_ Net-_U1-Pad5_ d_inverter
U11 Net-_U10-Pad2_ Net-_U11-Pad2_ d_inverter
X2 Net-_U2-Pad2_ Net-_U8-Pad2_ Net-_U4-Pad2_ Net-_U5-Pad2_ Net-_U1-Pad3_ Net-_X2-Pad6_ 5_and
X1 Net-_U2-Pad2_ Net-_U3-Pad2_ Net-_U4-Pad2_ Net-_U5-Pad2_ Net-_U1-Pad4_ Net-_X1-Pad6_ 5_and
U12 Net-_U11-Pad2_ Net-_U1-Pad6_ d_inverter
X9 Net-_U2-Pad2_ Net-_U3-Pad2_ Net-_U6-Pad2_ Net-_U7-Pad2_ Net-_U1-Pad13_ Net-_X8-Pad2_ 5_and
X10 Net-_U2-Pad2_ Net-_U6-Pad2_ Net-_U8-Pad2_ Net-_U7-Pad2_ Net-_U1-Pad12_ Net-_X10-Pad6_ 5_and
U4 Net-_U1-Pad10_ Net-_U4-Pad2_ d_inverter
U5 Net-_U1-Pad9_ Net-_U5-Pad2_ d_inverter
U7 Net-_U4-Pad2_ Net-_U7-Pad2_ d_inverter
U8 Net-_U3-Pad2_ Net-_U8-Pad2_ d_inverter
U6 Net-_U5-Pad2_ Net-_U6-Pad2_ d_inverter
U3 Net-_U1-Pad11_ Net-_U3-Pad2_ d_inverter
U2 Net-_U1-Pad7_ Net-_U2-Pad2_ d_inverter
.end
