* C:\FOSSEE\eSim\library\SubcircuitLibrary\TA7642\TA7642.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/03/25 11:57:32

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_C1-Pad2_ eSim_NPN
Q2  Net-_C1-Pad2_ Net-_Q2-Pad2_ Net-_Q10-Pad3_ eSim_NPN
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 12p
R2  Net-_C1-Pad1_ Net-_Q4-Pad2_ 3.3k
R3  Net-_Q1-Pad1_ Net-_Q3-Pad1_ 12k
R4  Net-_Q3-Pad1_ Net-_Q4-Pad2_ 12k
Q3  Net-_Q3-Pad1_ Net-_Q2-Pad2_ Net-_Q10-Pad3_ eSim_NPN
R1  Net-_Q3-Pad1_ Net-_Q2-Pad2_ 5.6k
R5  Net-_Q1-Pad1_ Net-_C2-Pad2_ 12k
Q4  Net-_C2-Pad2_ Net-_Q4-Pad2_ Net-_Q10-Pad3_ eSim_NPN
C2  Net-_C2-Pad1_ Net-_C2-Pad2_ 12p
R6  Net-_Q1-Pad1_ Net-_C3-Pad2_ 12k
Q5  Net-_C3-Pad2_ Net-_C2-Pad1_ Net-_Q10-Pad3_ eSim_NPN
R9  Net-_Q1-Pad1_ Net-_Q6-Pad1_ 12k
R7  Net-_C2-Pad1_ Net-_Q6-Pad1_ 12k
Q6  Net-_Q6-Pad1_ Net-_Q6-Pad2_ Net-_Q10-Pad3_ eSim_NPN
R8  Net-_Q6-Pad1_ Net-_Q6-Pad2_ 12k
R10  Net-_Q6-Pad1_ Net-_C3-Pad1_ 12k
C3  Net-_C3-Pad1_ Net-_C3-Pad2_ 12p
R11  Net-_Q1-Pad1_ Net-_C4-Pad2_ 12k
Q7  Net-_C4-Pad2_ Net-_C3-Pad1_ Net-_Q10-Pad3_ eSim_NPN
R13  Net-_Q1-Pad1_ Net-_Q8-Pad1_ 12k
Q8  Net-_Q8-Pad1_ Net-_Q8-Pad2_ Net-_Q10-Pad3_ eSim_NPN
R12  Net-_Q8-Pad1_ Net-_Q8-Pad2_ 12k
C4  Net-_C4-Pad1_ Net-_C4-Pad2_ 23p
R14  Net-_Q8-Pad1_ Net-_C4-Pad1_ 74k
R15  Net-_Q1-Pad1_ Net-_Q10-Pad2_ 12k
Q9  Net-_Q10-Pad2_ Net-_C4-Pad1_ Net-_Q10-Pad3_ eSim_NPN
Q10  Net-_Q1-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
U1  Net-_Q10-Pad3_ Net-_Q1-Pad2_ Net-_Q1-Pad1_ PORT

.end
