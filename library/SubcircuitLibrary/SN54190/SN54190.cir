* C:\Users\chand\eSim\FOSSEE\eSim\library\SubcircuitLibrary\SN54190\SN54190.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 02/17/26 20:44:06

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
X1  Net-_U4-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad7_ Net-_U17-Pad1_ 3_and
X2  Net-_U3-Pad1_ Net-_U32-Pad7_ Net-_U35-Pad7_ Net-_X2-Pad4_ 3_and
U17  Net-_U17-Pad1_ Net-_U17-Pad2_ Net-_U1-Pad12_ d_or
X3  Net-_X2-Pad4_ Net-_U38-Pad7_ Net-_U15-Pad2_ Net-_U17-Pad2_ 3_and
U10  Net-_U1-Pad15_ Net-_U10-Pad2_ Net-_U10-Pad3_ d_nand
U32  Net-_U22-Pad2_ Net-_U22-Pad2_ Net-_U26-Pad2_ Net-_U31-Pad2_ Net-_U32-Pad5_ Net-_U1-Pad3_ Net-_U32-Pad7_ d_jkff
U33  Net-_U16-Pad3_ Net-_U32-Pad5_ d_inverter
U31  Net-_U10-Pad3_ Net-_U31-Pad2_ d_inverter
U9  Net-_U1-Pad4_ Net-_U22-Pad2_ d_inverter
U16  Net-_U10-Pad3_ Net-_U10-Pad2_ Net-_U16-Pad3_ d_nand
U22  Net-_U22-Pad1_ Net-_U22-Pad2_ Net-_U22-Pad3_ d_nand
U43  Net-_U30-Pad3_ Net-_U1-Pad12_ Net-_U1-Pad13_ d_nand
U30  Net-_U22-Pad3_ Net-_U22-Pad3_ Net-_U30-Pad3_ d_nand
U26  Net-_U22-Pad1_ Net-_U26-Pad2_ d_inverter
U5  Net-_U1-Pad14_ Net-_U22-Pad1_ d_inverter
U6  Net-_U1-Pad5_ Net-_U4-Pad2_ d_inverter
U7  Net-_U4-Pad2_ Net-_U3-Pad1_ d_inverter
U3  Net-_U3-Pad1_ Net-_U1-Pad4_ Net-_U3-Pad3_ d_nor
U4  Net-_U1-Pad4_ Net-_U4-Pad2_ Net-_U4-Pad3_ d_nor
U38  Net-_U19-Pad3_ Net-_U19-Pad3_ Net-_U28-Pad2_ Net-_U37-Pad2_ Net-_U38-Pad5_ Net-_U1-Pad6_ Net-_U38-Pad7_ d_jkff
U39  Net-_U24-Pad3_ Net-_U38-Pad5_ d_inverter
U37  Net-_U13-Pad3_ Net-_U37-Pad2_ d_inverter
U28  Net-_U22-Pad1_ Net-_U28-Pad2_ d_inverter
U24  Net-_U13-Pad3_ Net-_U10-Pad2_ Net-_U24-Pad3_ d_nand
U19  Net-_U19-Pad1_ Net-_U19-Pad2_ Net-_U19-Pad3_ d_or
U35  Net-_U18-Pad3_ Net-_U18-Pad3_ Net-_U27-Pad2_ Net-_U34-Pad2_ Net-_U35-Pad5_ Net-_U1-Pad2_ Net-_U35-Pad7_ d_jkff
U36  Net-_U23-Pad3_ Net-_U35-Pad5_ d_inverter
U34  Net-_U12-Pad3_ Net-_U34-Pad2_ d_inverter
U27  Net-_U22-Pad1_ Net-_U27-Pad2_ d_inverter
U23  Net-_U12-Pad3_ Net-_U10-Pad2_ Net-_U23-Pad3_ d_nand
U18  Net-_U18-Pad1_ Net-_U18-Pad2_ Net-_U18-Pad3_ d_or
U41  Net-_U20-Pad3_ Net-_U20-Pad3_ Net-_U29-Pad2_ Net-_U40-Pad2_ Net-_U41-Pad5_ Net-_U1-Pad7_ Net-_U15-Pad2_ d_jkff
U42  Net-_U25-Pad3_ Net-_U41-Pad5_ d_inverter
U40  Net-_U14-Pad3_ Net-_U40-Pad2_ d_inverter
U29  Net-_U22-Pad1_ Net-_U29-Pad2_ d_inverter
U25  Net-_U14-Pad3_ Net-_U10-Pad2_ Net-_U25-Pad3_ d_nand
U21  Net-_U21-Pad1_ Net-_U21-Pad2_ Net-_U20-Pad1_ d_or
U12  Net-_U1-Pad1_ Net-_U10-Pad2_ Net-_U12-Pad3_ d_nand
X4  Net-_U4-Pad3_ Net-_U32-Pad7_ Net-_U15-Pad3_ Net-_U18-Pad1_ 3_and
X5  Net-_U1-Pad3_ Net-_U15-Pad2_ Net-_U3-Pad3_ Net-_U18-Pad2_ 3_and
U8  Net-_U35-Pad7_ Net-_U38-Pad7_ Net-_U11-Pad1_ d_nand
U15  Net-_U11-Pad3_ Net-_U15-Pad2_ Net-_U15-Pad3_ d_nand
U11  Net-_U11-Pad1_ Net-_U11-Pad1_ Net-_U11-Pad3_ d_nand
U13  Net-_U1-Pad10_ Net-_U10-Pad2_ Net-_U13-Pad3_ d_nand
X7  Net-_U15-Pad3_ Net-_U4-Pad3_ Net-_U32-Pad7_ Net-_U35-Pad7_ Net-_U19-Pad1_ 4_and
U14  Net-_U1-Pad9_ Net-_U10-Pad2_ Net-_U14-Pad3_ d_nand
X9  Net-_U4-Pad3_ Net-_U32-Pad7_ Net-_U35-Pad7_ Net-_U38-Pad7_ Net-_U21-Pad1_ 4_and
X6  Net-_U1-Pad3_ Net-_U1-Pad7_ Net-_U3-Pad3_ Net-_U21-Pad2_ 3_and
X10  Net-_U1-Pad3_ Net-_U1-Pad2_ Net-_U1-Pad6_ Net-_U3-Pad3_ Net-_U20-Pad2_ 4_and
U20  Net-_U20-Pad1_ Net-_U20-Pad2_ Net-_U20-Pad3_ d_or
U2  Net-_U1-Pad11_ Net-_U10-Pad2_ d_inverter
X8  Net-_U1-Pad3_ Net-_U1-Pad2_ Net-_U3-Pad3_ Net-_U19-Pad2_ 3_and
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ ? Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ ? PORT

.end
