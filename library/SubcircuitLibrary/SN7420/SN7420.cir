* C:\FOSSEE\eSim\library\SubcircuitLibrary\SN7420\SN7420.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 02/11/25 17:51:11

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
R1  Net-_R1-Pad1_ Net-_Q1-Pad2_ 4k
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_D1-Pad2_ eSim_NPN
Q2  Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_D2-Pad2_ eSim_NPN
Q3  Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_D3-Pad2_ eSim_NPN
Q4  Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_D4-Pad2_ eSim_NPN
D1  GND Net-_D1-Pad2_ eSim_Diode
D2  GND Net-_D2-Pad2_ eSim_Diode
D3  GND Net-_D3-Pad2_ eSim_Diode
D4  GND Net-_D4-Pad2_ eSim_Diode
Q5  Net-_Q5-Pad1_ Net-_Q1-Pad1_ Net-_Q5-Pad3_ eSim_NPN
R3  Net-_R1-Pad1_ Net-_Q5-Pad1_ 1.6k
Q6  Net-_Q6-Pad1_ Net-_Q5-Pad1_ Net-_D5-Pad1_ eSim_NPN
R4  Net-_R1-Pad1_ Net-_Q6-Pad1_ 130
D5  Net-_D5-Pad1_ Net-_D5-Pad2_ eSim_Diode
Q7  Net-_D5-Pad2_ Net-_Q5-Pad3_ GND eSim_NPN
R2  Net-_Q5-Pad3_ GND 1k
R5  Net-_R1-Pad1_ Net-_Q10-Pad2_ 4k
Q8  Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_D6-Pad2_ eSim_NPN
Q9  Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_D7-Pad2_ eSim_NPN
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_D8-Pad2_ eSim_NPN
Q11  Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_D9-Pad2_ eSim_NPN
D6  GND Net-_D6-Pad2_ eSim_Diode
D7  GND Net-_D7-Pad2_ eSim_Diode
D8  GND Net-_D8-Pad2_ eSim_Diode
D9  GND Net-_D9-Pad2_ eSim_Diode
Q12  Net-_Q12-Pad1_ Net-_Q10-Pad1_ Net-_Q12-Pad3_ eSim_NPN
R7  Net-_R1-Pad1_ Net-_Q12-Pad1_ 1.6k
Q13  Net-_Q13-Pad1_ Net-_Q12-Pad1_ Net-_D10-Pad1_ eSim_NPN
R8  Net-_R1-Pad1_ Net-_Q13-Pad1_ 130
D10  Net-_D10-Pad1_ Net-_D10-Pad2_ eSim_Diode
Q14  Net-_D10-Pad2_ Net-_Q12-Pad3_ GND eSim_NPN
R6  Net-_Q12-Pad3_ GND 1k
U1  Net-_D1-Pad2_ Net-_D2-Pad2_ GND Net-_D3-Pad2_ Net-_D4-Pad2_ Net-_D5-Pad2_ GND Net-_D10-Pad2_ Net-_D6-Pad2_ Net-_D7-Pad2_ GND Net-_D8-Pad2_ Net-_D9-Pad2_ Net-_R1-Pad1_ PORT

.end
