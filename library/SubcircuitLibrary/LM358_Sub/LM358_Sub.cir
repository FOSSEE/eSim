* C:\FOSSEE\eSim\library\SubcircuitLibrary\LM358_Sub\LM358_Sub.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 07/14/24 10:45:14

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
Q2  Net-_Q2-Pad1_ Net-_Q1-Pad3_ Net-_I1-Pad2_ eSim_PNP
Q1  Net-_I10-Pad2_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_PNP
Q5  Net-_C1-Pad2_ Net-_Q5-Pad2_ Net-_I1-Pad2_ eSim_PNP
Q6  Net-_I10-Pad2_ Net-_Q6-Pad2_ Net-_Q5-Pad2_ eSim_PNP
I1  Net-_I1-Pad1_ Net-_I1-Pad2_ 6uA
Q3  Net-_Q2-Pad1_ Net-_Q2-Pad1_ Net-_I10-Pad2_ eSim_NPN
Q4  Net-_C1-Pad2_ Net-_Q2-Pad1_ Net-_I10-Pad2_ eSim_NPN
Q7  Net-_I10-Pad2_ Net-_C1-Pad2_ Net-_I2-Pad2_ eSim_PNP
Q8  Net-_I1-Pad1_ Net-_I2-Pad2_ Net-_I3-Pad1_ eSim_NPN
Q9  Net-_C1-Pad1_ Net-_I3-Pad1_ Net-_I10-Pad2_ eSim_NPN
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 20pF
I4  Net-_I1-Pad1_ Net-_C1-Pad1_ 100uA
Q11  Net-_I1-Pad1_ Net-_C1-Pad1_ Net-_Q11-Pad3_ eSim_NPN
Q10  Net-_C1-Pad1_ Net-_Q10-Pad2_ Net-_I5-Pad1_ eSim_NPN
Q12  Net-_I1-Pad1_ Net-_Q11-Pad3_ Net-_Q10-Pad2_ eSim_NPN
R3  Net-_Q10-Pad2_ Net-_I5-Pad1_ 300
Q13  Net-_I10-Pad2_ Net-_C1-Pad1_ Net-_I5-Pad1_ eSim_PNP
I5  Net-_I5-Pad1_ Net-_I10-Pad2_ 50uA
R1  Net-_R1-Pad1_ Net-_Q1-Pad2_ 4k
R2  Net-_Q1-Pad2_ Net-_I5-Pad1_ 10k
I2  Net-_I1-Pad1_ Net-_I2-Pad2_ 4uA
I3  Net-_I3-Pad1_ Net-_I10-Pad2_ 50uA
U1  Net-_I5-Pad1_ Net-_R1-Pad1_ Net-_Q6-Pad2_ Net-_I10-Pad2_ Net-_Q19-Pad2_ Net-_R4-Pad1_ Net-_I10-Pad1_ Net-_I1-Pad1_ PORT
Q15  Net-_Q15-Pad1_ Net-_Q14-Pad3_ Net-_I6-Pad2_ eSim_PNP
Q14  Net-_I10-Pad2_ Net-_Q14-Pad2_ Net-_Q14-Pad3_ eSim_PNP
Q18  Net-_C2-Pad2_ Net-_Q18-Pad2_ Net-_I6-Pad2_ eSim_PNP
Q19  Net-_I10-Pad2_ Net-_Q19-Pad2_ Net-_Q18-Pad2_ eSim_PNP
I6  Net-_I1-Pad1_ Net-_I6-Pad2_ 6uA
Q16  Net-_Q15-Pad1_ Net-_Q15-Pad1_ Net-_I10-Pad2_ eSim_NPN
Q17  Net-_C2-Pad2_ Net-_Q15-Pad1_ Net-_I10-Pad2_ eSim_NPN
Q20  Net-_I10-Pad2_ Net-_C2-Pad2_ Net-_I7-Pad2_ eSim_PNP
Q21  Net-_I1-Pad1_ Net-_I7-Pad2_ Net-_I8-Pad1_ eSim_NPN
Q22  Net-_C2-Pad1_ Net-_I8-Pad1_ Net-_I10-Pad2_ eSim_NPN
C2  Net-_C2-Pad1_ Net-_C2-Pad2_ 20pF
I9  Net-_I1-Pad1_ Net-_C2-Pad1_ 100uA
Q24  Net-_I1-Pad1_ Net-_C2-Pad1_ Net-_Q24-Pad3_ eSim_NPN
Q23  Net-_C2-Pad1_ Net-_Q23-Pad2_ Net-_I10-Pad1_ eSim_NPN
Q25  Net-_I1-Pad1_ Net-_Q24-Pad3_ Net-_Q23-Pad2_ eSim_NPN
R6  Net-_Q23-Pad2_ Net-_I10-Pad1_ 300
Q26  Net-_I10-Pad2_ Net-_C2-Pad1_ Net-_I10-Pad1_ eSim_PNP
I10  Net-_I10-Pad1_ Net-_I10-Pad2_ 50uA
R4  Net-_R4-Pad1_ Net-_Q14-Pad2_ 4k
R5  Net-_Q14-Pad2_ Net-_I10-Pad1_ 10k
I7  Net-_I1-Pad1_ Net-_I7-Pad2_ 4uA
I8  Net-_I8-Pad1_ Net-_I10-Pad2_ 50uA

.end
