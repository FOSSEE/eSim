* C:\FOSSEE\eSim\library\SubcircuitLibrary\LM311\LM311.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 04/26/25 12:53:00

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
R1  Balance/Strobe Net-_Q4-Pad3_ 300
U1  plus Minus Balance/Strobe Balance Vminus Vplus Output Net-_Q19-Pad3_ PORT
R3  Balance Net-_Q2-Pad3_ 300
R4  Vplus Net-_Q4-Pad3_ 1.3k
Q2  Net-_Q1-Pad3_ Net-_Q2-Pad2_ Net-_Q2-Pad3_ eSim_PNP
Q4  Net-_Q3-Pad3_ Net-_Q2-Pad2_ Net-_Q4-Pad3_ eSim_PNP
R2  Vplus Net-_Q2-Pad3_ 1.3k
Q6  Vplus Vplus Net-_Q6-Pad3_ eSim_NPN
R6  Net-_Q6-Pad3_ Net-_Q2-Pad2_ 70
Q9  Net-_Q12-Pad1_ Net-_Q2-Pad2_ Balance/Strobe eSim_NPN
R5  Net-_Q2-Pad2_ Net-_Q10-Pad2_ 1.2k
R7  Net-_Q2-Pad2_ Net-_Q12-Pad2_ 1.2k
Q1  Vminus plus Net-_Q1-Pad3_ eSim_PNP
U2  Net-_U2-PadIN_ Net-_Q1-Pad3_ zener
U3  Net-_U2-PadIN_ Net-_Q3-Pad3_ zener
Q5  Net-_Q10-Pad2_ Net-_Q1-Pad3_ Net-_Q5-Pad3_ eSim_NPN
Q3  Vminus Minus Net-_Q3-Pad3_ eSim_PNP
Q7  Net-_Q12-Pad2_ Net-_Q3-Pad3_ Net-_Q5-Pad3_ eSim_NPN
Q8  Net-_Q5-Pad3_ Net-_Q11-Pad2_ Net-_Q8-Pad3_ eSim_NPN
R8  Net-_Q8-Pad3_ Vminus 250
R9  Vplus Net-_Q10-Pad1_ 750
Q13  Vplus Net-_Q10-Pad1_ Net-_Q13-Pad3_ eSim_NPN
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
Q12  Net-_Q12-Pad1_ Net-_Q12-Pad2_ Net-_Q10-Pad3_ eSim_NPN
Q11  Net-_Q10-Pad3_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_NPN
R10  Vminus Net-_Q11-Pad3_ 200
R11  Net-_Q11-Pad2_ Net-_R11-Pad2_ 60
Q14  Net-_Q11-Pad2_ Net-_Q14-Pad2_ Vminus eSim_NPN
R14  Net-_Q14-Pad2_ Vminus 2k
R13  Net-_R11-Pad2_ Net-_Q14-Pad2_ 450
R12  Net-_Q16-Pad3_ Net-_R11-Pad2_ 400
Q16  Net-_Q13-Pad3_ Net-_J1-Pad3_ Net-_Q16-Pad3_ eSim_NPN
Q15  Net-_Q15-Pad1_ Net-_Q13-Pad3_ Net-_Q12-Pad1_ eSim_PNP
R15  Vplus Net-_Q12-Pad1_ 600
J1  Vplus Vminus Net-_J1-Pad3_ jfet_n
Q17  Net-_J1-Pad3_ Net-_Q16-Pad3_ Net-_Q17-Pad3_ eSim_NPN
Q18  Vminus Vminus Net-_Q17-Pad3_ eSim_PNP
R16  Net-_Q15-Pad1_ Net-_Q22-Pad3_ 4k
Q22  Vplus Net-_Q15-Pad1_ Net-_Q22-Pad3_ eSim_NPN
Q20  Net-_Q15-Pad1_ Net-_Q15-Pad1_ Net-_Q20-Pad3_ eSim_NPN
Q21  Vminus Output Net-_Q20-Pad3_ eSim_PNP
R17  Net-_Q22-Pad3_ Net-_Q23-Pad2_ 130
R18  Net-_Q23-Pad2_ Net-_Q19-Pad2_ 600
Q19  Net-_Q15-Pad1_ Net-_Q19-Pad2_ Net-_Q19-Pad3_ eSim_NPN
Q23  Output Net-_Q23-Pad2_ Net-_Q19-Pad2_ eSim_NPN
R19  Net-_Q19-Pad2_ Net-_Q19-Pad3_ 4

.end
