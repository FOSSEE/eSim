* D:\FOSSEE\eSim\library\SubcircuitLibrary\SN74LS295B\SN74LS295B.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 07/06/25 11:49:39

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U5  Net-_U1-Pad2_ /1 Net-_U5-Pad3_ d_and
U8  /2 Net-_U13-Pad2_ Net-_U7-Pad1_ d_and
U7  Net-_U7-Pad1_ Net-_U5-Pad3_ Net-_U6-Pad1_ d_nor
U9  Net-_U1-Pad2_ Net-_U10-Pad1_ Net-_U11-Pad2_ d_and
U13  /3 Net-_U13-Pad2_ Net-_U11-Pad1_ d_and
U11  Net-_U11-Pad1_ Net-_U11-Pad2_ Net-_U11-Pad3_ d_nor
U14  Net-_U1-Pad2_ Net-_U14-Pad2_ Net-_U14-Pad3_ d_and
U18  /4 Net-_U13-Pad2_ Net-_U15-Pad1_ d_and
U15  Net-_U15-Pad1_ Net-_U14-Pad3_ Net-_U15-Pad3_ d_nor
U19  Net-_U1-Pad2_ Net-_U19-Pad2_ Net-_U19-Pad3_ d_and
U22  /5 Net-_U13-Pad2_ Net-_U20-Pad1_ d_and
U20  Net-_U20-Pad1_ Net-_U19-Pad3_ Net-_U20-Pad3_ d_nor
X1  Net-_U6-Pad2_ Net-_U2-Pad2_ Net-_U6-Pad1_ ? Net-_U10-Pad1_ SR_FF1
X2  Net-_U12-Pad2_ Net-_U2-Pad2_ Net-_U11-Pad3_ ? Net-_U14-Pad2_ SR_FF1
X3  Net-_U16-Pad2_ Net-_U2-Pad2_ Net-_U15-Pad3_ ? Net-_U19-Pad2_ SR_FF1
X4  Net-_U21-Pad2_ Net-_U2-Pad2_ Net-_U20-Pad3_ ? Net-_U24-Pad1_ SR_FF1
U6  Net-_U6-Pad1_ Net-_U6-Pad2_ d_inverter
U2  /9 Net-_U2-Pad2_ d_inverter
U12  Net-_U11-Pad3_ Net-_U12-Pad2_ d_inverter
U16  Net-_U15-Pad3_ Net-_U16-Pad2_ d_inverter
U21  Net-_U20-Pad3_ Net-_U21-Pad2_ d_inverter
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ /13 d_tristate
U17  Net-_U14-Pad2_ Net-_U10-Pad2_ /12 d_tristate
U23  Net-_U19-Pad2_ Net-_U10-Pad2_ /11 d_tristate
U24  Net-_U24-Pad1_ Net-_U10-Pad2_ /10 d_tristate
U3  /8 Net-_U10-Pad2_ d_buffer
U1  /6 Net-_U1-Pad2_ d_inverter
U4  Net-_U1-Pad2_ Net-_U13-Pad2_ d_inverter
U25  /1 /2 /3 /4 /5 /6 ? /8 /9 /10 /11 /12 /13 ? PORT

.end
