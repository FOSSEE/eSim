* C:\ESIM\FOSSEE\eSim\library\SubcircuitLibrary\NE555_Subcircuit\NE555_Subcircuit.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 12/08/24 12:13:38

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
R13  Net-_Q18-Pad3_ Net-_D2-Pad2_ 6.8k
Q21  Net-_Q18-Pad3_ Net-_D2-Pad2_ Net-_Q21-Pad3_ eSim_NPN
R14  Net-_Q21-Pad3_ Net-_D2-Pad1_ 3.8k
Q22  Net-_Q18-Pad3_ Net-_Q21-Pad3_ Net-_D2-Pad1_ eSim_NPN
R8  Net-_Q18-Pad3_ Net-_Q11-Pad2_ 75k
R6  Net-_Q18-Pad3_ Net-_Q13-Pad3_ 41k
R5  Net-_Q18-Pad3_ Net-_Q10-Pad3_ 4.7k
R4  Net-_Q18-Pad3_ Net-_Q6-Pad3_ 330
R1  Net-_Q18-Pad3_ Net-_Q1-Pad3_ 4.7k
Q6  Net-_Q16-Pad1_ Net-_Q1-Pad1_ Net-_Q6-Pad3_ eSim_PNP
Q8  GND Net-_Q10-Pad1_ Net-_Q6-Pad3_ eSim_PNP
Q2  Net-_Q1-Pad1_ Net-_Q2-Pad2_ Net-_Q2-Pad3_ eSim_NPN
Q5  Net-_Q1-Pad1_ Net-_Q2-Pad3_ Net-_Q5-Pad3_ eSim_NPN
Q7  Net-_Q10-Pad1_ Net-_Q11-Pad3_ Net-_Q5-Pad3_ eSim_NPN
R2  Net-_Q5-Pad3_ GND 10k
Q4  Net-_Q3-Pad2_ Net-_Q4-Pad2_ Net-_D1-Pad1_ eSim_PNP
Q3  Net-_Q3-Pad1_ Net-_Q3-Pad2_ GND eSim_NPN
R3  Net-_Q3-Pad2_ Net-_Q20-Pad3_ 100
Q9  GND Net-_Q9-Pad2_ Net-_Q12-Pad2_ eSim_PNP
Q12  Net-_Q12-Pad1_ Net-_Q12-Pad2_ Net-_Q12-Pad3_ eSim_PNP
Q14  GND Net-_Q14-Pad2_ Net-_Q12-Pad3_ eSim_PNP
Q15  GND Net-_Q15-Pad2_ Net-_Q14-Pad2_ eSim_PNP
R7  Net-_Q12-Pad1_ GND 100k
R9  Net-_Q11-Pad2_ Net-_Q15-Pad2_ 5k
R10  Net-_Q15-Pad2_ GND 5k
Q16  Net-_Q16-Pad1_ Net-_Q12-Pad1_ GND eSim_NPN
Q17  Net-_D1-Pad2_ Net-_Q16-Pad1_ GND eSim_NPN
Q19  Net-_Q18-Pad1_ Net-_D1-Pad2_ GND eSim_NPN
Q20  Net-_D2-Pad2_ Net-_Q18-Pad1_ Net-_Q20-Pad3_ eSim_NPN
R12  Net-_Q16-Pad1_ Net-_Q18-Pad1_ 4.7k
D1  Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
R11  Net-_Q13-Pad2_ Net-_D1-Pad1_ 82k
D2  Net-_D2-Pad1_ Net-_D2-Pad2_ eSim_Diode
R16  Net-_Q20-Pad3_ Net-_Q23-Pad2_ 220
R15  Net-_Q20-Pad3_ GND 4.7k
Q23  Net-_D2-Pad1_ Net-_Q23-Pad2_ GND eSim_NPN
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad1_ Net-_Q1-Pad3_ eSim_PNP
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad1_ Net-_Q10-Pad3_ eSim_PNP
Q18  Net-_Q18-Pad1_ Net-_Q13-Pad2_ Net-_Q18-Pad3_ eSim_PNP
Q11  Net-_Q10-Pad1_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_NPN
Q13  Net-_Q12-Pad3_ Net-_Q13-Pad2_ Net-_Q13-Pad3_ eSim_PNP
U1  Net-_Q2-Pad2_ Net-_Q9-Pad2_ Net-_Q4-Pad2_ Net-_Q3-Pad1_ GND Net-_Q18-Pad3_ Net-_Q11-Pad2_ Net-_D2-Pad1_ PORT

.end
