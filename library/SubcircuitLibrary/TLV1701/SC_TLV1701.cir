* C:\FOSSEE2\eSim\library\SubcircuitLibrary\SC_TLV1701\SC_TLV1701.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/07/25 13:23:03

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
Q1  Net-_I2-Pad2_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
Q4  Net-_I2-Pad2_ Net-_Q4-Pad2_ Net-_Q4-Pad3_ eSim_NPN
Q2  Net-_Q12-Pad3_ Net-_I1-Pad2_ Net-_I2-Pad1_ eSim_PNP
Q3  Net-_Q10-Pad3_ Net-_I3-Pad2_ Net-_I2-Pad1_ eSim_PNP
Q5  Net-_I1-Pad1_ Net-_Q1-Pad2_ Net-_Q5-Pad3_ eSim_PNP
Q8  Net-_I1-Pad1_ Net-_Q4-Pad2_ Net-_Q8-Pad3_ eSim_PNP
Q6  Net-_Q11-Pad3_ Net-_I4-Pad1_ Net-_I5-Pad2_ eSim_NPN
Q7  Net-_Q7-Pad1_ Net-_I6-Pad1_ Net-_I5-Pad2_ eSim_NPN
Q9  Net-_Q10-Pad1_ Net-_Q11-Pad2_ Net-_Q7-Pad1_ eSim_PNP
Q11  Net-_Q11-Pad1_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_PNP
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
Q12  Net-_Q11-Pad1_ Net-_Q10-Pad2_ Net-_Q12-Pad3_ eSim_NPN
Q13  Net-_I1-Pad1_ Net-_Q11-Pad1_ Net-_I7-Pad1_ eSim_PNP
Q14  Net-_I2-Pad2_ Net-_I7-Pad1_ Net-_I8-Pad2_ eSim_NPN
Q15  Net-_Q15-Pad1_ Net-_I8-Pad2_ Net-_I1-Pad1_ eSim_NPN
R1  Net-_Q1-Pad3_ Net-_I1-Pad2_ 10k
R2  Net-_Q4-Pad3_ Net-_I3-Pad2_ 10k
I2  Net-_I2-Pad1_ Net-_I2-Pad2_ dc
I1  Net-_I1-Pad1_ Net-_I1-Pad2_ dc
I3  Net-_I1-Pad1_ Net-_I3-Pad2_ dc
R3  Net-_I4-Pad1_ Net-_Q5-Pad3_ 10k
R4  Net-_I6-Pad1_ Net-_Q8-Pad3_ 10k
I5  Net-_I1-Pad1_ Net-_I5-Pad2_ dc
R5  Net-_Q10-Pad3_ Net-_I1-Pad1_ 10k
R8  Net-_I1-Pad1_ Net-_Q12-Pad3_ 10k
I8  Net-_I1-Pad1_ Net-_I8-Pad2_ dc
I4  Net-_I4-Pad1_ Net-_I2-Pad2_ dc
I6  Net-_I6-Pad1_ Net-_I2-Pad2_ dc
R6  Net-_Q7-Pad1_ Net-_I2-Pad2_ 10k
R7  Net-_I2-Pad2_ Net-_Q11-Pad3_ 10k
I7  Net-_I7-Pad1_ Net-_I2-Pad2_ dc
U1  Net-_Q1-Pad2_ Net-_I1-Pad1_ Net-_Q4-Pad2_ Net-_Q15-Pad1_ Net-_I2-Pad2_ PORT

.end
