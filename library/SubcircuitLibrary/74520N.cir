* C:\Users\pt710\eSim-Workspace\74520N\74520N.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 03/21/25 12:10:14

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
X1  Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ Net-_U1-Pad16_ Net-_X1-Pad9_ Net-_X1-Pad10_ Net-_X1-Pad11_ Net-_X1-Pad12_ CD4077
X2  Net-_U2-Pad9_ Net-_U2-Pad10_ Net-_U2-Pad11_ Net-_U2-Pad12_ Net-_U2-Pad13_ Net-_U2-Pad14_ Net-_U2-Pad15_ Net-_U2-Pad16_ Net-_X2-Pad9_ Net-_X2-Pad10_ Net-_X2-Pad11_ Net-_X2-Pad12_ CD4077
X3  Net-_X1-Pad9_ Net-_X1-Pad10_ Net-_X1-Pad11_ Net-_X1-Pad12_ Net-_U3-Pad1_ Net-_X2-Pad12_ Net-_X2-Pad11_ Net-_X2-Pad10_ Net-_X2-Pad9_ Net-_U3-Pad2_ 7421
U1  Net-_U1-Pad1_ Net-_U1-Pad1_ Net-_U1-Pad3_ Net-_U1-Pad3_ Net-_U1-Pad5_ Net-_U1-Pad5_ Net-_U1-Pad5_ Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ Net-_U1-Pad16_ adc_bridge_8
U2  Net-_U2-Pad1_ Net-_U2-Pad2_ Net-_U2-Pad3_ Net-_U2-Pad4_ Net-_U2-Pad5_ Net-_U2-Pad6_ Net-_U2-Pad7_ Net-_U2-Pad8_ Net-_U2-Pad9_ Net-_U2-Pad10_ Net-_U2-Pad11_ Net-_U2-Pad12_ Net-_U2-Pad13_ Net-_U2-Pad14_ Net-_U2-Pad15_ Net-_U2-Pad16_ adc_bridge_8
R1  out GND 10k
U5  out plot_v1
v1  Net-_U1-Pad1_ GND DC
U3  Net-_U3-Pad1_ Net-_U3-Pad2_ Net-_U3-Pad3_ d_and
v2  Net-_U1-Pad3_ GND DC
v3  Net-_U1-Pad5_ GND DC
v4  Net-_U1-Pad8_ GND DC
v5  Net-_U2-Pad1_ GND DC
v6  Net-_U2-Pad2_ GND DC
v7  Net-_U2-Pad3_ GND DC
v8  Net-_U2-Pad4_ GND DC
v9  Net-_U2-Pad5_ GND DC
v10  Net-_U2-Pad6_ GND DC
v11  Net-_U2-Pad7_ GND DC
v12  Net-_U2-Pad8_ GND DC
U4  Net-_U3-Pad3_ out dac_bridge_1

.end
