.title KiCad schematic
Q2 Net-_Q1-Pad2_ Net-_Q2-Pad2_ Net-_D4-Pad1_ eSim_PNP
U1 Net-_U1-PadIN_ Net-_R4-Pad2_ zener
R4 Net-_Q2-Pad2_ Net-_R4-Pad2_ 15k
U2 Net-_Q3-Pad2_ Net-_U1-PadIN_ zener
R3 Net-_D4-Pad1_ Net-_Q2-Pad2_ 15k
Q4 Net-_C1-Pad1_ Net-_D2-Pad2_ Net-_D2-Pad2_ eSim_NPN
I2 Net-_Q3-Pad3_ Net-_C1-Pad1_ 2m
R6 Net-_D2-Pad2_ Net-_D1-Pad1_ 100k
R5 Net-_Q3-Pad3_ Net-_D1-Pad1_ 100k
Q3 Net-_D4-Pad1_ Net-_Q3-Pad2_ Net-_Q3-Pad3_ eSim_NPN
I1 Net-_D4-Pad1_ Net-_Q3-Pad2_ 3m
R7 Net-_D4-Pad1_ Net-_D3-Pad1_ 47k
I3 Net-_D4-Pad1_ Net-_C2-Pad1_ 2m
C2 Net-_C2-Pad1_ Net-_C1-Pad1_ 10p
C1 Net-_C1-Pad1_ Net-_C1-Pad2_ 10p
R8 Net-_C1-Pad2_ Net-_D2-Pad2_ 47k
Q6 Net-_C2-Pad1_ Net-_C1-Pad1_ Net-_Q6-Pad3_ eSim_NPN
Q7 Net-_C2-Pad1_ Net-_C2-Pad1_ Net-_Q12-Pad2_ eSim_NPN
Q9 Net-_C2-Pad1_ Net-_Q14-Pad1_ Net-_D2-Pad2_ eSim_NPN
Q8 Net-_Q12-Pad2_ Net-_Q6-Pad3_ Net-_D2-Pad2_ eSim_NPN
R1 Net-_Q3-Pad3_ Net-_Q1-Pad2_ 47k
Q1 Net-_C2-Pad1_ Net-_Q1-Pad2_ Net-_D2-Pad2_ eSim_NPN
R2 Net-_Q1-Pad2_ Net-_D2-Pad2_ 47k
U3 Net-_D2-Pad2_ Net-_Q3-Pad2_ zener
U5 Net-_D2-Pad2_ Net-_D2-Pad2_ Net-_D2-Pad2_ Net-_C1-Pad2_ Net-_D4-Pad1_ PORT
D2 Net-_D1-Pad2_ Net-_D2-Pad2_ eSim_Diode
D1 Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
Q12 Net-_Q12-Pad1_ Net-_Q12-Pad2_ Net-_Q12-Pad3_ eSim_PNP
I5 Net-_D8-Pad2_ Net-_D2-Pad2_ 50m
Q16 Net-_C1-Pad2_ Net-_Q12-Pad1_ Net-_D2-Pad2_ eSim_NPN
D6 Net-_D6-Pad1_ Net-_D6-Pad2_ eSim_Diode
D7 Net-_D6-Pad2_ Net-_C1-Pad2_ eSim_Diode
Q15 Net-_D8-Pad1_ Net-_D5-Pad1_ Net-_C1-Pad2_ eSim_NPN
Q14 Net-_Q14-Pad1_ Net-_D8-Pad2_ Net-_D4-Pad1_ eSim_PNP
I4 Net-_D4-Pad1_ Net-_D6-Pad1_ 25m
R10 Net-_D4-Pad1_ Net-_D8-Pad1_ 10
D8 Net-_D8-Pad1_ Net-_D8-Pad2_ eSim_Diode
U4 Net-_R9-Pad1_ Net-_D8-Pad2_ zener
R9 Net-_R9-Pad1_ Net-_C1-Pad2_ 22k
Q11 Net-_D5-Pad1_ Net-_D4-Pad2_ Net-_D4-Pad1_ eSim_PNP
Q10 Net-_D4-Pad2_ Net-_C2-Pad1_ Net-_C1-Pad2_ eSim_NPN
D5 Net-_D5-Pad1_ Net-_C1-Pad2_ eSim_Diode
Q13 Net-_D4-Pad1_ Net-_D6-Pad1_ Net-_Q12-Pad3_ eSim_NPN
D4 Net-_D4-Pad1_ Net-_D4-Pad2_ eSim_Diode
D3 Net-_D3-Pad1_ Net-_D2-Pad2_ eSim_Diode
Q5 Net-_D2-Pad2_ Net-_D3-Pad1_ Net-_D2-Pad2_ eSim_NPN
.end
