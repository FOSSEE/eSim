* C:\FOSSEE\eSim\library\SubcircuitLibrary\CD54HC7266\CD54HC7266.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/19/25 12:08:31

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ d_inverter
U2  Net-_U10-Pad1_ Net-_U2-Pad2_ d_inverter
U9  Net-_U1-Pad1_ Net-_U2-Pad2_ Net-_U17-Pad1_ d_and
U10  Net-_U10-Pad1_ Net-_U1-Pad2_ Net-_U10-Pad3_ d_and
U17  Net-_U17-Pad1_ Net-_U10-Pad3_ Net-_U17-Pad3_ d_or
U21  Net-_U17-Pad3_ Net-_U21-Pad2_ d_inverter
U3  Net-_U11-Pad1_ Net-_U12-Pad2_ d_inverter
U4  Net-_U12-Pad1_ Net-_U11-Pad2_ d_inverter
U11  Net-_U11-Pad1_ Net-_U11-Pad2_ Net-_U11-Pad3_ d_and
U12  Net-_U12-Pad1_ Net-_U12-Pad2_ Net-_U12-Pad3_ d_and
U18  Net-_U11-Pad3_ Net-_U12-Pad3_ Net-_U18-Pad3_ d_or
U22  Net-_U18-Pad3_ Net-_U22-Pad2_ d_inverter
U5  Net-_U13-Pad1_ Net-_U14-Pad2_ d_inverter
U6  Net-_U14-Pad1_ Net-_U13-Pad2_ d_inverter
U13  Net-_U13-Pad1_ Net-_U13-Pad2_ Net-_U13-Pad3_ d_and
U14  Net-_U14-Pad1_ Net-_U14-Pad2_ Net-_U14-Pad3_ d_and
U19  Net-_U13-Pad3_ Net-_U14-Pad3_ Net-_U19-Pad3_ d_or
U23  Net-_U19-Pad3_ Net-_U23-Pad2_ d_inverter
U7  Net-_U15-Pad1_ Net-_U16-Pad2_ d_inverter
U8  Net-_U16-Pad1_ Net-_U15-Pad2_ d_inverter
U15  Net-_U15-Pad1_ Net-_U15-Pad2_ Net-_U15-Pad3_ d_and
U16  Net-_U16-Pad1_ Net-_U16-Pad2_ Net-_U16-Pad3_ d_and
U20  Net-_U15-Pad3_ Net-_U16-Pad3_ Net-_U20-Pad3_ d_or
U24  Net-_U20-Pad3_ Net-_U24-Pad2_ d_inverter
U25  Net-_U1-Pad1_ Net-_U10-Pad1_ Net-_U21-Pad2_ Net-_U22-Pad2_ Net-_U11-Pad1_ Net-_U12-Pad1_ ? Net-_U13-Pad1_ Net-_U14-Pad1_ Net-_U23-Pad2_ Net-_U24-Pad2_ Net-_U15-Pad1_ Net-_U16-Pad1_ ? PORT

.end
