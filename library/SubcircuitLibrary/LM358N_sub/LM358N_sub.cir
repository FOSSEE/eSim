.title KiCad schematic
I5 Net-_I1-Pad1_ Net-_Q15-Pad3_ 6u
Q15 Net-_Q15-Pad1_ Net-_Q14-Pad3_ Net-_Q15-Pad3_ eSim_PNP
U1 Net-_Q10-Pad3_ Net-_Q1-Pad2_ Net-_Q6-Pad2_ GND Net-_Q19-Pad2_ Net-_Q14-Pad2_ Net-_Q23-Pad3_ Net-_I1-Pad1_ PORT
Q14 GND Net-_Q14-Pad2_ Net-_Q14-Pad3_ eSim_PNP
Q16 Net-_Q15-Pad1_ Net-_Q15-Pad1_ GND eSim_NPN
Q23 Net-_C2-Pad2_ Net-_Q23-Pad2_ Net-_Q23-Pad3_ eSim_NPN
Q24 Net-_I1-Pad1_ Net-_C2-Pad2_ Net-_Q24-Pad3_ eSim_NPN
I7 Net-_I1-Pad1_ Net-_C2-Pad2_ 100u
Q25 Net-_I1-Pad1_ Net-_Q24-Pad3_ Net-_Q23-Pad2_ eSim_NPN
R4 Net-_Q23-Pad3_ Net-_Q23-Pad2_ 50
Q22 Net-_C2-Pad2_ Net-_Q21-Pad3_ GND eSim_NPN
I8 Net-_Q23-Pad3_ GND 50u
Q26 GND Net-_C2-Pad2_ Net-_Q23-Pad3_ eSim_PNP
Q20 GND Net-_C2-Pad1_ Net-_Q20-Pad3_ eSim_PNP
R3 GND Net-_Q21-Pad3_ 1k
Q21 Net-_I1-Pad1_ Net-_Q20-Pad3_ Net-_Q21-Pad3_ eSim_NPN
Q18 Net-_C2-Pad1_ Net-_Q18-Pad2_ Net-_Q15-Pad3_ eSim_PNP
C2 Net-_C2-Pad1_ Net-_C2-Pad2_ 30p
I6 Net-_I1-Pad1_ Net-_Q20-Pad3_ 4.0u
Q17 Net-_C2-Pad1_ Net-_Q15-Pad1_ GND eSim_NPN
Q19 GND Net-_Q19-Pad2_ Net-_Q18-Pad2_ eSim_PNP
I1 Net-_I1-Pad1_ Net-_Q2-Pad3_ 6u
C1 Net-_C1-Pad1_ Net-_C1-Pad2_ 30p
R2 Net-_Q10-Pad3_ Net-_Q10-Pad2_ 50
Q11 Net-_I1-Pad1_ Net-_C1-Pad2_ Net-_Q11-Pad3_ eSim_NPN
Q12 Net-_I1-Pad1_ Net-_Q11-Pad3_ Net-_Q10-Pad2_ eSim_NPN
Q9 Net-_C1-Pad2_ Net-_Q8-Pad3_ GND eSim_NPN
Q8 Net-_I1-Pad1_ Net-_Q7-Pad3_ Net-_Q8-Pad3_ eSim_NPN
R1 GND Net-_Q8-Pad3_ 1k
Q10 Net-_C1-Pad2_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
I2 Net-_I1-Pad1_ Net-_Q7-Pad3_ 4.0u
I3 Net-_I1-Pad1_ Net-_C1-Pad2_ 100u
Q13 GND Net-_C1-Pad2_ Net-_Q10-Pad3_ eSim_PNP
I4 Net-_Q10-Pad3_ GND 50u
Q7 GND Net-_C1-Pad1_ Net-_Q7-Pad3_ eSim_PNP
Q4 Net-_C1-Pad1_ Net-_Q2-Pad1_ GND eSim_NPN
Q3 Net-_Q2-Pad1_ Net-_Q2-Pad1_ GND eSim_NPN
Q1 GND Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_PNP
Q5 Net-_C1-Pad1_ Net-_Q5-Pad2_ Net-_Q2-Pad3_ eSim_PNP
Q6 GND Net-_Q6-Pad2_ Net-_Q5-Pad2_ eSim_PNP
Q2 Net-_Q2-Pad1_ Net-_Q1-Pad3_ Net-_Q2-Pad3_ eSim_PNP
.end
