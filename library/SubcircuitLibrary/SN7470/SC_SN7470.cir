* C:\FOSSEE2\eSim\library\SubcircuitLibrary\SC_SN7470\SC_SN7470.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 07/06/25 17:08:36

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
X4  Net-_U4-Pad1_ Net-_U12-Pad1_ Net-_U1-Pad2_ Net-_U15-Pad1_ 3_and
X2  Net-_U1-Pad13_ Net-_U10-Pad1_ Net-_U15-Pad2_ Net-_U6-Pad1_ 3_and
U15  Net-_U15-Pad1_ Net-_U15-Pad2_ d_inverter
U6  Net-_U6-Pad1_ Net-_U4-Pad1_ d_inverter
X3  Net-_U12-Pad1_ Net-_U7-Pad2_ Net-_U4-Pad1_ Net-_U8-Pad1_ 3_and
X5  Net-_U15-Pad2_ Net-_U16-Pad2_ Net-_U10-Pad1_ Net-_U13-Pad1_ 3_and
U11  Net-_U1-Pad12_ Net-_U11-Pad2_ d_inverter
U4  Net-_U4-Pad1_ Net-_U1-Pad6_ d_inverter
U17  Net-_U15-Pad2_ Net-_U1-Pad8_ d_inverter
X6  Net-_U1-Pad3_ Net-_U1-Pad2_ Net-_U1-Pad6_ Net-_U12-Pad1_ Net-_U18-Pad2_ 4_and
U19  Net-_U19-Pad1_ Net-_U1-Pad4_ Net-_U18-Pad1_ d_and
U20  Net-_U1-Pad5_ Net-_U19-Pad1_ d_inverter
U18  Net-_U18-Pad1_ Net-_U18-Pad2_ Net-_U16-Pad1_ d_and
X1  Net-_U1-Pad10_ Net-_U1-Pad13_ Net-_U1-Pad8_ Net-_U10-Pad1_ Net-_U5-Pad2_ 4_and
U3  Net-_U2-Pad2_ Net-_U1-Pad11_ Net-_U3-Pad3_ d_and
U2  Net-_U1-Pad9_ Net-_U2-Pad2_ d_inverter
U5  Net-_U3-Pad3_ Net-_U5-Pad2_ Net-_U5-Pad3_ d_and
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
Q2  Net-_Q2-Pad1_ Net-_Q2-Pad2_ Net-_Q2-Pad3_ eSim_NPN
U1  ? Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ ? Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ ? PORT
U7  Net-_U5-Pad3_ Net-_U7-Pad2_ d_inverter
U16  Net-_U16-Pad1_ Net-_U16-Pad2_ d_inverter
U8  Net-_U8-Pad1_ Net-_Q1-Pad2_ dac_bridge_1
U13  Net-_U13-Pad1_ Net-_Q2-Pad2_ dac_bridge_1
U9  Net-_U11-Pad2_ Net-_Q1-Pad3_ dac_bridge_1
U10  Net-_U10-Pad1_ Net-_Q1-Pad1_ dac_bridge_1
U14  Net-_U11-Pad2_ Net-_Q2-Pad3_ dac_bridge_1
U12  Net-_U12-Pad1_ Net-_Q2-Pad1_ dac_bridge_1

.end
