* C:\Users\HP\OneDrive\Documents\FOSSEE\eSim\library\SubcircuitLibrary\NJU7091A\NJU7091A.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/23/25 12:30:58

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
M1  Net-_M1-Pad1_ Net-_M1-Pad2_ Net-_M1-Pad2_ Net-_M1-Pad1_ mosfet_p
M4  Net-_M4-Pad1_ Net-_M1-Pad2_ Net-_M2-Pad2_ Net-_M4-Pad1_ mosfet_p
M2  Net-_M1-Pad2_ Net-_M2-Pad2_ Net-_M11-Pad4_ Net-_M11-Pad4_ mosfet_n
M3  Net-_M2-Pad2_ Net-_M2-Pad2_ Net-_M11-Pad4_ Net-_M11-Pad4_ mosfet_n
R1  Net-_M1-Pad1_ Net-_M4-Pad1_ 1k
M5  Net-_M13-Pad2_ Net-_M13-Pad2_ Net-_M11-Pad4_ Net-_M11-Pad4_ mosfet_n
M7  Net-_M13-Pad2_ Net-_C1-Pad1_ Net-_M11-Pad4_ Net-_M11-Pad4_ mosfet_n
M10  Net-_M1-Pad1_ Net-_M1-Pad2_ Net-_M10-Pad3_ Net-_M1-Pad1_ mosfet_p
M6  Net-_M1-Pad1_ Net-_M1-Pad2_ Net-_M13-Pad2_ Net-_M1-Pad1_ mosfet_p
M8  Net-_M10-Pad3_ Net-_M8-Pad2_ Net-_M11-Pad2_ Net-_M1-Pad1_ mosfet_p
M12  Net-_M10-Pad3_ Net-_M12-Pad2_ Net-_C1-Pad1_ Net-_M1-Pad1_ mosfet_p
M9  Net-_M11-Pad2_ Net-_M11-Pad2_ Net-_M9-Pad3_ Net-_M11-Pad4_ mosfet_n
M11  Net-_C1-Pad1_ Net-_M11-Pad2_ Net-_M11-Pad3_ Net-_M11-Pad4_ mosfet_n
M14  Net-_M1-Pad1_ Net-_M13-Pad1_ Net-_M13-Pad1_ Net-_M1-Pad1_ mosfet_p
M16  Net-_M1-Pad1_ Net-_M13-Pad1_ Net-_C1-Pad2_ Net-_M1-Pad1_ mosfet_p
M13  Net-_M13-Pad1_ Net-_M13-Pad2_ Net-_M11-Pad4_ Net-_M11-Pad4_ mosfet_n
M15  Net-_C1-Pad2_ Net-_C1-Pad1_ Net-_M11-Pad4_ Net-_M11-Pad4_ mosfet_n
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 60p
R2  Net-_M9-Pad3_ Net-_M11-Pad4_ 3k
R3  Net-_M11-Pad3_ Net-_M11-Pad4_ 3k
U1  Net-_M1-Pad1_ Net-_M8-Pad2_ Net-_M12-Pad2_ Net-_M11-Pad4_ Net-_C1-Pad2_ PORT

.end
