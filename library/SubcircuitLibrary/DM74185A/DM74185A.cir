* C:\Users\HP\OneDrive\Documents\FOSSEE\eSim\library\SubcircuitLibrary\DM74185A\DM74185A.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 05/30/25 16:33:50

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U2  /B Net-_U2-Pad2_ d_inverter
U3  /C Net-_U3-Pad2_ d_inverter
U4  /D Net-_U4-Pad2_ d_inverter
U5  /E Net-_U5-Pad2_ d_inverter
U6  /A /A /Y1 d_or
X1  Net-_U5-Pad2_ Net-_U4-Pad2_ Net-_U3-Pad2_ /B Net-_X1-Pad5_ 4_and
X2  Net-_U5-Pad2_ Net-_U4-Pad2_ /C /B Net-_X2-Pad5_ 4_and
X4  Net-_U5-Pad2_ /D /C Net-_U2-Pad2_ Net-_X3-Pad3_ 4_and
X5  /E Net-_U4-Pad2_ Net-_U3-Pad2_ Net-_U2-Pad2_ Net-_X3-Pad4_ 4_and
X7  /E Net-_U4-Pad2_ /C /B Net-_X6-Pad3_ 4_and
X8  /E /D Net-_U3-Pad2_ /B Net-_X6-Pad4_ 4_and
X3  Net-_X1-Pad5_ Net-_X2-Pad5_ Net-_X3-Pad3_ Net-_X3-Pad4_ Net-_X3-Pad5_ 4_OR
X6  Net-_X3-Pad5_ Net-_X3-Pad5_ Net-_X6-Pad3_ Net-_X6-Pad4_ /Y2 4_OR
X11  Net-_U5-Pad2_ /D /C /B Net-_X11-Pad5_ 4_and
X17  /E Net-_U4-Pad2_ Net-_U3-Pad2_ Net-_U2-Pad2_ Net-_X12-Pad4_ 4_and
X9  Net-_U5-Pad2_ Net-_U4-Pad2_ /C Net-_X12-Pad1_ 3_and
X15  /E /D Net-_U3-Pad2_ Net-_X12-Pad3_ 3_and
X12  Net-_X12-Pad1_ Net-_X11-Pad5_ Net-_X12-Pad3_ Net-_X12-Pad4_ /Y3 4_OR
X18  Net-_U5-Pad2_ /D Net-_U3-Pad2_ Net-_U2-Pad2_ Net-_X18-Pad5_ 4_and
X19  /E Net-_U4-Pad2_ Net-_U3-Pad2_ /B Net-_X19-Pad5_ 4_and
X21  /E /D /C Net-_U2-Pad2_ Net-_X20-Pad4_ 4_and
X20  Net-_X18-Pad5_ Net-_X18-Pad5_ Net-_X19-Pad5_ Net-_X20-Pad4_ /Y4 4_OR
X16  /B /C /D /E Net-_X13-Pad4_ 4_and
X14  Net-_U3-Pad2_ Net-_U4-Pad2_ /E Net-_X13-Pad3_ 3_and
U9  /C /B Net-_U9-Pad3_ d_or
X10  Net-_U5-Pad2_ /D Net-_U9-Pad3_ Net-_X10-Pad4_ 3_and
X13  Net-_X10-Pad4_ Net-_X10-Pad4_ Net-_X13-Pad3_ Net-_X13-Pad4_ /Y5 4_OR
U8  /D /C Net-_U7-Pad2_ d_or
U7  /E Net-_U7-Pad2_ /Y6 d_and
U1  /A /B /C /D /E ? ? ? /Y1 GND /Y2 GND /Y6 /Y3 /Y5 /Y4 PORT

.end
