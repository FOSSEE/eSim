.title KiCad schematic
R5 Net-_C4-Pad1_ Net-_Q5-Pad3_ 4k
R6 Net-_C4-Pad1_ Net-_Q16-Pad3_ 20k
C1 Net-_C1-Pad1_ Net-_C1-Pad2_ 100p
R8 Net-_C4-Pad1_ Net-_C1-Pad2_ 10k
Q6 Net-_C3-Pad1_ Net-_Q16-Pad3_ Net-_C1-Pad1_ eSim_NPN
R7 Net-_C4-Pad1_ Net-_C1-Pad1_ 4k
Q7 Net-_I3-Pad1_ Net-_D3-Pad2_ Net-_C3-Pad1_ eSim_NPN
Q16 Net-_I3-Pad1_ Net-_D3-Pad2_ Net-_Q16-Pad3_ eSim_NPN
D3 Net-_C3-Pad1_ Net-_D3-Pad2_ eSim_Diode
D4 Net-_D4-Pad1_ Net-_D4-Pad2_ eSim_Diode
D5 Net-_D4-Pad2_ Net-_D5-Pad2_ eSim_Diode
I4 Net-_I3-Pad1_ Net-_D4-Pad1_ 1m
Q11 Net-_I3-Pad1_ Net-_D4-Pad1_ Net-_Q11-Pad3_ eSim_NPN
Q13 Net-_Q13-Pad1_ Net-_Q10-Pad1_ Net-_C4-Pad1_ eSim_PNP
Q10 Net-_Q10-Pad1_ Net-_D7-Pad2_ Net-_C4-Pad1_ eSim_PNP
R14 Net-_Q13-Pad1_ Net-_C2-Pad2_ 0.15
C2 Net-_C1-Pad2_ Net-_C2-Pad2_ 20p
R13 Net-_C2-Pad2_ Net-_Q11-Pad3_ 200
D6 Net-_D5-Pad2_ Net-_D6-Pad2_ eSim_Diode
R12 Net-_Q10-Pad1_ Net-_C2-Pad2_ 200
U1 Net-_R1-Pad1_ Net-_R2-Pad1_ Net-_C2-Pad2_ Net-_I3-Pad1_ Net-_C4-Pad1_ PORT
R16 Net-_Q14-Pad2_ Net-_I3-Pad1_ 1
R15 Net-_C2-Pad2_ Net-_Q12-Pad3_ 0.15
Q12 Net-_I3-Pad1_ Net-_Q11-Pad3_ Net-_Q12-Pad3_ eSim_NPN
Q14 Net-_C4-Pad1_ Net-_Q14-Pad2_ Net-_C2-Pad2_ eSim_NPN
C4 Net-_C4-Pad1_ Net-_C3-Pad1_ 50p
R9 Net-_C4-Pad1_ Net-_Q8-Pad3_ 20k
R10 Net-_Q8-Pad3_ Net-_Q9-Pad2_ 3k
Q9 Net-_D7-Pad2_ Net-_Q9-Pad2_ Net-_Q9-Pad3_ eSim_NPN
R11 Net-_C4-Pad1_ Net-_Q9-Pad3_ 50
D7 Net-_D6-Pad2_ Net-_D7-Pad2_ eSim_Diode
Q8 Net-_I3-Pad1_ Net-_C3-Pad1_ Net-_Q8-Pad3_ eSim_NPN
C3 Net-_C3-Pad1_ Net-_C2-Pad2_ 5p
Q3 Net-_D3-Pad2_ Net-_I2-Pad1_ Net-_Q3-Pad3_ eSim_PNP
Q2 Net-_I3-Pad1_ Net-_D2-Pad2_ Net-_I2-Pad1_ eSim_NPN
D2 Net-_C4-Pad1_ Net-_D2-Pad2_ eSim_Diode
R17 Net-_C4-Pad1_ Net-_Q15-Pad2_ 1
Q15 Net-_I3-Pad1_ Net-_Q15-Pad2_ Net-_C2-Pad2_ eSim_PNP
I1 Net-_I1-Pad1_ Net-_C4-Pad1_ 15u
Q5 Net-_D3-Pad2_ Net-_Q16-Pad3_ Net-_Q5-Pad3_ eSim_NPN
I2 Net-_I2-Pad1_ Net-_C4-Pad1_ 15u
R4 Net-_Q4-Pad3_ Net-_I3-Pad2_ 5k
Q4 Net-_C3-Pad1_ Net-_I1-Pad1_ Net-_Q4-Pad3_ eSim_PNP
R3 Net-_Q3-Pad3_ Net-_I3-Pad2_ 5k
I3 Net-_I3-Pad1_ Net-_I3-Pad2_ 80u
Q1 Net-_I3-Pad1_ Net-_D1-Pad2_ Net-_I1-Pad1_ eSim_NPN
R1 Net-_R1-Pad1_ Net-_D1-Pad2_ 3k
R2 Net-_R2-Pad1_ Net-_D2-Pad2_ 3k
D1 Net-_C4-Pad1_ Net-_D1-Pad2_ eSim_Diode
.end
