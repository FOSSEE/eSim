* C:\FOSSEE\eSim\library\SubcircuitLibrary\ICS83840\ICS83840.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 01/30/26 15:38:54

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U6  Net-_M6-Pad2_ Net-_U6-Pad2_ adc_bridge_1
U8  Net-_U6-Pad2_ Net-_U11-Pad1_ d_inverter
M4  HP0 Net-_M4-Pad2_ Net-_M4-Pad3_ GND eSim_MOS_N
M6  HP0 Net-_M6-Pad2_ Net-_M4-Pad3_ VDD eSim_MOS_P
M11  GND Net-_M11-Pad2_ Net-_M11-Pad3_ GND eSim_MOS_N
U20  Net-_U17-Pad2_ Net-_U20-Pad2_ d_inverter
U11  Net-_U11-Pad1_ Net-_M4-Pad2_ dac_bridge_1
U17  Net-_M4-Pad2_ Net-_U17-Pad2_ adc_bridge_1
U22  Net-_U20-Pad2_ Net-_M11-Pad2_ dac_bridge_1
R3  Net-_M11-Pad3_ Net-_M4-Pad3_ 20
U12  Net-_M9-Pad2_ Net-_U12-Pad2_ adc_bridge_1
U14  Net-_U12-Pad2_ Net-_U14-Pad2_ d_inverter
M8  HP0 Net-_M8-Pad2_ Net-_M8-Pad3_ GND eSim_MOS_N
M9  HP0 Net-_M9-Pad2_ Net-_M8-Pad3_ VDD eSim_MOS_P
M12  GND Net-_M12-Pad2_ Net-_M12-Pad3_ GND eSim_MOS_N
U24  Net-_U23-Pad2_ Net-_U24-Pad2_ d_inverter
U18  Net-_U14-Pad2_ Net-_M8-Pad2_ dac_bridge_1
U23  Net-_M8-Pad2_ Net-_U23-Pad2_ adc_bridge_1
U25  Net-_U24-Pad2_ Net-_M12-Pad2_ dac_bridge_1
R4  Net-_M12-Pad3_ Net-_M8-Pad3_ 20
U5  Net-_M5-Pad2_ Net-_U5-Pad2_ adc_bridge_1
U7  Net-_U5-Pad2_ Net-_U10-Pad1_ d_inverter
M3  HP0 Net-_M3-Pad2_ Net-_M3-Pad3_ GND eSim_MOS_N
M5  HP0 Net-_M5-Pad2_ Net-_M3-Pad3_ VDD eSim_MOS_P
M10  GND Net-_M10-Pad2_ Net-_M10-Pad3_ GND eSim_MOS_N
U19  Net-_U16-Pad2_ Net-_U19-Pad2_ d_inverter
U10  Net-_U10-Pad1_ Net-_M3-Pad2_ dac_bridge_1
U16  Net-_M3-Pad2_ Net-_U16-Pad2_ adc_bridge_1
U21  Net-_U19-Pad2_ Net-_M10-Pad2_ dac_bridge_1
R2  Net-_M10-Pad3_ Net-_M3-Pad3_ 20
U2  Net-_M2-Pad2_ Net-_U2-Pad2_ adc_bridge_1
U3  Net-_U2-Pad2_ Net-_U3-Pad2_ d_inverter
M1  HP0 Net-_M1-Pad2_ Net-_M1-Pad3_ GND eSim_MOS_N
M2  HP0 Net-_M2-Pad2_ Net-_M1-Pad3_ VDD eSim_MOS_P
M7  GND Net-_M7-Pad2_ Net-_M7-Pad3_ GND eSim_MOS_N
U13  Net-_U13-Pad1_ Net-_U13-Pad2_ d_inverter
U4  Net-_U3-Pad2_ Net-_M1-Pad2_ dac_bridge_1
U9  Net-_M1-Pad2_ Net-_U13-Pad1_ adc_bridge_1
U15  Net-_U13-Pad2_ Net-_M7-Pad2_ dac_bridge_1
R1  Net-_M7-Pad3_ Net-_M1-Pad3_ 20
U1  Net-_M2-Pad2_ HP0 Net-_M5-Pad2_ Net-_M6-Pad2_ Net-_M9-Pad2_ Net-_M1-Pad3_ Net-_M3-Pad3_ Net-_M4-Pad3_ VDD GND Net-_M8-Pad3_ PORT

.end
