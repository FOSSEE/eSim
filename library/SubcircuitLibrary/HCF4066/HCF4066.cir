* C:\FOSSEE\eSim\library\SubcircuitLibrary\HCF4066\HCF4066.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 07/14/25 15:06:53

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
M1  Net-_M1-Pad1_ Net-_M1-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad1_ mosfet_p
M3  Net-_M1-Pad1_ Net-_M3-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M2  Net-_M1-Pad3_ Net-_M1-Pad2_ GND GND mosfet_n
X1  Net-_U1-Pad5_ Net-_M1-Pad2_ INVCMOS
X2  Net-_M1-Pad2_ Net-_M3-Pad2_ INVCMOS
M4  Net-_C1-Pad1_ Net-_M1-Pad2_ Net-_M1-Pad1_ Net-_M1-Pad1_ mosfet_p
M5  Net-_C1-Pad1_ Net-_M3-Pad2_ Net-_M1-Pad1_ Net-_M1-Pad3_ mosfet_n
C1  Net-_C1-Pad1_ GND 100p
U1  Net-_M10-Pad3_ Net-_C2-Pad1_ Net-_C1-Pad1_ Net-_M1-Pad1_ Net-_U1-Pad5_ Net-_U1-Pad6_ GND Net-_M11-Pad1_ Net-_C3-Pad1_ Net-_C4-Pad1_ Net-_M12-Pad1_ Net-_U1-Pad12_ Net-_U1-Pad13_ GND PORT
M12  Net-_M12-Pad1_ Net-_M12-Pad2_ Net-_M12-Pad3_ Net-_M12-Pad1_ mosfet_p
M16  Net-_M12-Pad1_ Net-_M16-Pad2_ Net-_M12-Pad3_ Net-_M12-Pad3_ mosfet_n
M14  Net-_M12-Pad3_ Net-_M12-Pad2_ GND GND mosfet_n
X6  Net-_U1-Pad12_ Net-_M12-Pad2_ INVCMOS
X8  Net-_M12-Pad2_ Net-_M16-Pad2_ INVCMOS
M18  Net-_C4-Pad1_ Net-_M12-Pad2_ Net-_M12-Pad1_ Net-_M12-Pad1_ mosfet_p
M20  Net-_C4-Pad1_ Net-_M16-Pad2_ Net-_M12-Pad1_ Net-_M12-Pad3_ mosfet_n
C4  Net-_C4-Pad1_ GND 100p
M6  Net-_M10-Pad3_ Net-_M6-Pad2_ Net-_M10-Pad4_ Net-_M10-Pad3_ mosfet_p
M8  Net-_M10-Pad3_ Net-_M10-Pad2_ Net-_M10-Pad4_ Net-_M10-Pad4_ mosfet_n
M7  Net-_M10-Pad4_ Net-_M6-Pad2_ GND GND mosfet_n
X3  Net-_U1-Pad13_ Net-_M6-Pad2_ INVCMOS
X4  Net-_M6-Pad2_ Net-_M10-Pad2_ INVCMOS
M9  Net-_C2-Pad1_ Net-_M6-Pad2_ Net-_M10-Pad3_ Net-_M10-Pad3_ mosfet_p
M10  Net-_C2-Pad1_ Net-_M10-Pad2_ Net-_M10-Pad3_ Net-_M10-Pad4_ mosfet_n
C2  Net-_C2-Pad1_ GND 100p
M11  Net-_M11-Pad1_ Net-_M11-Pad2_ Net-_M11-Pad3_ Net-_M11-Pad1_ mosfet_p
M15  Net-_M11-Pad1_ Net-_M15-Pad2_ Net-_M11-Pad3_ Net-_M11-Pad3_ mosfet_n
M13  Net-_M11-Pad3_ Net-_M11-Pad2_ GND GND mosfet_n
X5  Net-_U1-Pad6_ Net-_M11-Pad2_ INVCMOS
X7  Net-_M11-Pad2_ Net-_M15-Pad2_ INVCMOS
M17  Net-_C3-Pad1_ Net-_M11-Pad2_ Net-_M11-Pad1_ Net-_M11-Pad1_ mosfet_p
M19  Net-_C3-Pad1_ Net-_M15-Pad2_ Net-_M11-Pad1_ Net-_M11-Pad3_ mosfet_n
C3  Net-_C3-Pad1_ GND 100p

.end
