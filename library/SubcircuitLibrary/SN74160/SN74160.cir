.title KiCad schematic
U29 Net-_U16-Pad2_ Net-_U29-Pad2_ d_inverter
U37 Net-_U25-Pad3_ Net-_U21-Pad3_ Net-_U29-Pad2_ unconnected-_U37-Pad4_ Net-_U33-Pad2_ unconnected-_U37-Pad6_ Net-_U1-Pad14_ d_jkff
U33 Net-_U33-Pad1_ Net-_U33-Pad2_ d_inverter
U1 Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ GND /load Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ GND PORT
U34 Net-_U33-Pad1_ Net-_U34-Pad2_ d_inverter
U40 Net-_U26-Pad3_ Net-_U22-Pad3_ Net-_U30-Pad2_ unconnected-_U40-Pad4_ Net-_U34-Pad2_ unconnected-_U40-Pad6_ Net-_U1-Pad13_ d_jkff
U39 Net-_U28-Pad3_ Net-_U24-Pad3_ Net-_U32-Pad2_ unconnected-_U39-Pad4_ Net-_U36-Pad2_ Net-_U1-Pad11_ Net-_U39-Pad7_ d_jkff
U36 Net-_U33-Pad1_ Net-_U36-Pad2_ d_inverter
U32 Net-_U16-Pad2_ Net-_U32-Pad2_ d_inverter
U35 Net-_U33-Pad1_ Net-_U35-Pad2_ d_inverter
U31 Net-_U16-Pad2_ Net-_U31-Pad2_ d_inverter
U27 Net-_U14-Pad3_ Net-_U19-Pad3_ Net-_U27-Pad3_ d_and
U22 Net-_U18-Pad3_ Net-_U13-Pad2_ Net-_U22-Pad3_ d_and
U30 Net-_U16-Pad2_ Net-_U30-Pad2_ d_inverter
U19 Net-_U19-Pad1_ Net-_U10-Pad2_ Net-_U19-Pad3_ d_or
U16 Net-_U1-Pad2_ Net-_U16-Pad2_ d_inverter
U38 Net-_U27-Pad3_ Net-_U23-Pad3_ Net-_U31-Pad2_ unconnected-_U38-Pad4_ Net-_U35-Pad2_ unconnected-_U38-Pad6_ Net-_U1-Pad12_ d_jkff
U9 Net-_U1-Pad4_ Net-_U10-Pad2_ Net-_U13-Pad2_ d_nand
X4 Net-_U1-Pad14_ Net-_U17-Pad1_ Net-_U39-Pad7_ Net-_U18-Pad1_ 3_and
U28 Net-_U15-Pad3_ Net-_U20-Pad3_ Net-_U28-Pad3_ d_and
U7 Net-_U7-Pad1_ Net-_U7-Pad2_ Net-_U20-Pad1_ d_or
X2 Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U17-Pad1_ Net-_U7-Pad1_ 4_and
U20 Net-_U20-Pad1_ Net-_U10-Pad2_ Net-_U20-Pad3_ d_or
U24 Net-_U20-Pad3_ Net-_U11-Pad3_ Net-_U24-Pad3_ d_and
U15 Net-_U10-Pad2_ Net-_U11-Pad3_ Net-_U15-Pad3_ d_nand
U23 Net-_U19-Pad3_ Net-_U10-Pad3_ Net-_U23-Pad3_ d_and
U10 Net-_U1-Pad5_ Net-_U10-Pad2_ Net-_U10-Pad3_ d_nand
U11 Net-_U1-Pad6_ Net-_U10-Pad2_ Net-_U11-Pad3_ d_nand
X1 Net-_U1-Pad14_ Net-_U17-Pad1_ Net-_U1-Pad11_ Net-_U7-Pad2_ 3_and
U14 Net-_U10-Pad2_ Net-_U10-Pad3_ Net-_U14-Pad3_ d_nand
X3 Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U17-Pad1_ Net-_U19-Pad1_ 3_and
U25 Net-_U12-Pad3_ Net-_U17-Pad3_ Net-_U25-Pad3_ d_and
U21 Net-_U17-Pad3_ Net-_U12-Pad2_ Net-_U21-Pad3_ d_and
U26 Net-_U13-Pad3_ Net-_U18-Pad3_ Net-_U26-Pad3_ d_and
U17 Net-_U17-Pad1_ Net-_U10-Pad2_ Net-_U17-Pad3_ d_or
U12 Net-_U10-Pad2_ Net-_U12-Pad2_ Net-_U12-Pad3_ d_nand
U18 Net-_U18-Pad1_ Net-_U10-Pad2_ Net-_U18-Pad3_ d_or
U13 Net-_U10-Pad2_ Net-_U13-Pad2_ Net-_U13-Pad3_ d_nand
U8 Net-_U1-Pad3_ Net-_U10-Pad2_ Net-_U12-Pad2_ d_nand
X5 Net-_U1-Pad11_ Net-_U1-Pad14_ Net-_U1-Pad10_ Net-_U1-Pad15_ 3_and
U3 Net-_U1-Pad7_ Net-_U1-Pad10_ Net-_U17-Pad1_ d_and
U5 Net-_U2-Pad2_ Net-_U33-Pad1_ d_inverter
U2 Net-_U1-Pad1_ Net-_U2-Pad2_ d_inverter
U6 Net-_U4-Pad2_ Net-_U10-Pad2_ d_buffer
U4 /load Net-_U4-Pad2_ d_inverter
.end
