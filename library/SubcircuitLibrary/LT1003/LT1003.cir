* C:\FOSSEE\eSim\library\SubcircuitLibrary\LT1003\LT1003.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 05/07/25 18:25:03

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U1  IN OUT GND PORT
Q2  Net-_J1-Pad1_ Net-_J1-Pad1_ IN eSim_PNP
Q3  Net-_Q1-Pad2_ Net-_J1-Pad1_ IN eSim_PNP
Q5  Net-_Q10-Pad1_ Net-_J1-Pad1_ IN eSim_PNP
J1  Net-_J1-Pad1_ GND Net-_J1-Pad3_ jfet_n
Q1  Net-_J1-Pad1_ Net-_Q1-Pad2_ Net-_J1-Pad3_ eSim_NPN
R1  Net-_J1-Pad3_ Net-_Q4-Pad2_ 4k
R2  Net-_Q4-Pad2_ GND 250
U2  GND Net-_Q1-Pad2_ zener
Q4  Net-_Q10-Pad1_ Net-_Q4-Pad2_ GND eSim_NPN
R3  Net-_Q6-Pad3_ GND 1k
R7  Net-_Q7-Pad3_ GND 100
Q7  Net-_Q10-Pad2_ Net-_Q6-Pad3_ Net-_Q7-Pad3_ eSim_NPN
Q6  Net-_Q6-Pad1_ Net-_Q6-Pad2_ Net-_Q6-Pad3_ eSim_NPN
R6  Net-_Q6-Pad2_ Net-_Q10-Pad2_ 130
R5  Net-_Q9-Pad3_ Net-_Q6-Pad2_ 2.4k
R4  Net-_Q6-Pad1_ Net-_Q9-Pad3_ 2k
Q9  Net-_Q6-Pad1_ Net-_Q6-Pad1_ Net-_Q9-Pad3_ eSim_NPN
Q8  Net-_J1-Pad1_ OUT Net-_Q6-Pad1_ eSim_NPN
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
R8  Net-_Q10-Pad3_ GND 12k
Q11  Net-_C1-Pad1_ Net-_Q10-Pad3_ Net-_Q11-Pad3_ eSim_NPN
R10  Net-_Q11-Pad3_ GND 825
R11  Net-_Q14-Pad3_ GND 4k
Q14  Net-_Q13-Pad3_ Net-_Q13-Pad3_ Net-_Q14-Pad3_ eSim_NPN
Q13  Net-_C1-Pad2_ Net-_C1-Pad1_ Net-_Q13-Pad3_ eSim_NPN
Q17  Net-_C1-Pad2_ Net-_Q13-Pad3_ GND eSim_NPN
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 30
R9  Net-_Q12-Pad3_ Net-_C1-Pad1_ 20k
Q12  OUT Net-_Q12-Pad2_ Net-_Q12-Pad3_ eSim_NPN
Q16  OUT OUT Net-_C1-Pad2_ eSim_NPN
R12  Net-_Q15-Pad3_ OUT 1k
Q15  Net-_Q10-Pad1_ Net-_Q10-Pad1_ Net-_Q15-Pad3_ eSim_NPN
Q18  GND OUT Net-_Q10-Pad1_ eSim_PNP
Q19  GND Net-_C2-Pad1_ Net-_Q10-Pad1_ eSim_PNP
C2  Net-_C2-Pad1_ GND 15
R15  Net-_C2-Pad1_ Net-_C3-Pad1_ 3k
R16  Net-_Q10-Pad1_ Net-_C3-Pad1_ 2k
C3  Net-_C3-Pad1_ Net-_C3-Pad2_ 10
Q20  Net-_C3-Pad1_ Net-_C3-Pad2_ OUT eSim_NPN
R17  Net-_C3-Pad2_ Net-_Q23-Pad1_ 2k
R18  Net-_Q23-Pad2_ Net-_Q23-Pad1_ 200
Q23  Net-_Q23-Pad1_ Net-_Q23-Pad2_ Net-_Q23-Pad3_ eSim_NPN
R20  Net-_Q10-Pad1_ Net-_Q23-Pad2_ 6k
R21  Net-_R21-Pad1_ Net-_Q23-Pad3_ 10k
U3  Net-_R21-Pad1_ IN zener
Q24  IN Net-_Q10-Pad1_ Net-_Q24-Pad3_ eSim_NPN
Q25  IN Net-_Q24-Pad3_ Net-_Q25-Pad3_ eSim_NPN
R23  Net-_Q24-Pad3_ Net-_Q25-Pad3_ 1k
R22  Net-_Q23-Pad3_ Net-_Q25-Pad3_ 50
R25  Net-_Q25-Pad3_ OUT 0.03
U4  GND OUT zener
Q21  OUT OUT Net-_Q21-Pad3_ eSim_NPN
R14  Net-_R14-Pad1_ Net-_Q21-Pad3_ 400
Q22  Net-_Q10-Pad2_ Net-_Q21-Pad3_ Net-_Q22-Pad3_ eSim_PNP
R13  Net-_Q12-Pad2_ Net-_R13-Pad2_ 200k
R19  Net-_Q22-Pad3_ Net-_Q25-Pad3_ 2k
R24  OUT GND 1k
R26  Net-_R13-Pad2_ GND 100k
R27  Net-_Q12-Pad2_ Net-_R14-Pad1_ 400

.end
