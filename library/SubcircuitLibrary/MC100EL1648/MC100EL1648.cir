* C:\Users\AJAY\OneDrive\Desktop\FOSSEE2.3\eSim\library\SubcircuitLibrary\MC100EL1648\MC100EL1648.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 11/29/25 21:04:16

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
Q2  Net-_Q1-Pad2_ Net-_Q1-Pad2_ Net-_D1-Pad1_ eSim_NPN
D1  Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
R3  Net-_Q1-Pad3_ Net-_Q5-Pad3_ 400
R2  Net-_Q3-Pad2_ Net-_Q1-Pad1_ 1.6k
R1  Net-_Q3-Pad1_ Net-_Q3-Pad2_ 800
R4  Net-_Q3-Pad1_ Net-_Q1-Pad2_ 1.36k
Q3  Net-_Q3-Pad1_ Net-_Q3-Pad2_ Net-_Q1-Pad1_ eSim_NPN
Q4  Net-_Q4-Pad1_ Net-_Q1-Pad2_ Net-_Q4-Pad3_ eSim_NPN
Q6  Net-_Q3-Pad1_ Net-_Q4-Pad1_ Net-_Q4-Pad3_ eSim_NPN
R5  Net-_Q4-Pad3_ Net-_Q5-Pad1_ 330
Q5  Net-_Q5-Pad1_ Net-_D2-Pad2_ Net-_Q5-Pad3_ eSim_NPN
R6  Net-_D2-Pad2_ Net-_R6-Pad2_ 16k
D2  Net-_D2-Pad1_ Net-_D2-Pad2_ eSim_Diode
R7  Net-_Q3-Pad1_ Net-_D2-Pad1_ 3.1k
Q7  Net-_D2-Pad1_ Net-_Q7-Pad2_ Net-_Q7-Pad3_ eSim_NPN
R8  Net-_Q7-Pad3_ Net-_Q5-Pad3_ 82
Q8  Net-_Q8-Pad1_ Net-_Q4-Pad1_ Net-_Q7-Pad2_ eSim_NPN
R10  Net-_Q7-Pad2_ Net-_Q5-Pad3_ 400
R9  Net-_Q3-Pad1_ Net-_Q8-Pad1_ 660
Q9  Net-_Q3-Pad1_ Net-_Q8-Pad1_ Net-_Q10-Pad3_ eSim_NPN
Q10  Net-_Q10-Pad1_ Net-_Q1-Pad1_ Net-_Q10-Pad3_ eSim_NPN
R12  Net-_Q3-Pad1_ Net-_Q10-Pad1_ 167
R11  Net-_Q10-Pad3_ Net-_Q5-Pad3_ 660
Q11  Net-_Q11-Pad1_ Net-_Q10-Pad1_ Net-_Q11-Pad3_ eSim_NPN
R13  Net-_Q11-Pad3_ Net-_Q5-Pad3_ 510
U1  Net-_Q4-Pad1_ Net-_Q3-Pad1_ Net-_Q11-Pad1_ Net-_Q11-Pad3_ Net-_D2-Pad1_ Net-_R6-Pad2_ Net-_D1-Pad2_ Net-_Q1-Pad2_ PORT

.end
