* D:\FOSSEE\eSim\library\SubcircuitLibrary\SN74LS148_IC\SN74LS148_IC.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/26/24 23:24:07

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U23  Net-_U11-Pad2_ Net-_U2-Pad9_ Net-_U23-Pad3_ d_nand
U24  Net-_U2-Pad10_ Net-_U2-Pad11_ Net-_U24-Pad3_ d_nand
U25  Net-_U2-Pad12_ Net-_U2-Pad13_ Net-_U25-Pad3_ d_nand
U26  Net-_U2-Pad14_ Net-_U2-Pad15_ Net-_U26-Pad3_ d_nand
U29  Net-_U23-Pad3_ Net-_U23-Pad3_ Net-_U29-Pad3_ d_nand
U30  Net-_U24-Pad3_ Net-_U24-Pad3_ Net-_U30-Pad3_ d_nand
U31  Net-_U25-Pad3_ Net-_U25-Pad3_ Net-_U31-Pad3_ d_nand
U32  Net-_U26-Pad3_ Net-_U26-Pad3_ Net-_U32-Pad3_ d_nand
U41  Net-_U29-Pad3_ Net-_U30-Pad3_ Net-_U41-Pad3_ d_nand
U42  Net-_U31-Pad3_ Net-_U32-Pad3_ Net-_U42-Pad3_ d_nand
U48  Net-_U41-Pad3_ Net-_U41-Pad3_ Net-_U48-Pad3_ d_nand
U49  Net-_U42-Pad3_ Net-_U42-Pad3_ Net-_U49-Pad3_ d_nand
U50  Net-_U48-Pad3_ Net-_U49-Pad3_ Net-_U50-Pad3_ d_nand
U53  Net-_U51-Pad3_ Net-_U10-Pad2_ Net-_U52-Pad1_ d_nand
U5  Net-_U2-Pad9_ Net-_U5-Pad2_ d_inverter
X5  Net-_U5-Pad2_ Net-_U12-Pad2_ Net-_U13-Pad2_ Net-_U15-Pad2_ Net-_U10-Pad2_ Net-_U35-Pad1_ 5_and
X2  Net-_U4-Pad2_ Net-_U13-Pad2_ Net-_U15-Pad2_ Net-_U10-Pad2_ Net-_U35-Pad2_ 4_and
X1  Net-_U14-Pad1_ Net-_U15-Pad2_ Net-_U10-Pad2_ Net-_U36-Pad1_ 3_and
U16  Net-_U16-Pad1_ Net-_U10-Pad2_ Net-_U16-Pad3_ d_and
U35  Net-_U35-Pad1_ Net-_U35-Pad2_ Net-_U35-Pad3_ d_nor
U36  Net-_U36-Pad1_ Net-_U16-Pad3_ Net-_U36-Pad3_ d_nor
U43  Net-_U35-Pad3_ Net-_U35-Pad3_ Net-_U43-Pad3_ d_nor
U44  Net-_U36-Pad3_ Net-_U36-Pad3_ Net-_U44-Pad3_ d_nor
U47  Net-_U43-Pad3_ Net-_U44-Pad3_ Net-_U47-Pad3_ d_nor
X3  Net-_U12-Pad1_ Net-_U13-Pad2_ Net-_U14-Pad2_ Net-_U10-Pad2_ Net-_U27-Pad1_ 4_and
X4  Net-_U4-Pad2_ Net-_U13-Pad2_ Net-_U14-Pad2_ Net-_U10-Pad2_ Net-_U27-Pad2_ 4_and
U17  Net-_U15-Pad1_ Net-_U10-Pad2_ Net-_U17-Pad3_ d_and
U18  Net-_U16-Pad1_ Net-_U10-Pad2_ Net-_U18-Pad3_ d_and
U27  Net-_U27-Pad1_ Net-_U27-Pad2_ Net-_U27-Pad3_ d_nor
U28  Net-_U17-Pad3_ Net-_U18-Pad3_ Net-_U28-Pad3_ d_nor
U37  Net-_U27-Pad3_ Net-_U27-Pad3_ Net-_U37-Pad3_ d_nor
U38  Net-_U28-Pad3_ Net-_U28-Pad3_ Net-_U38-Pad3_ d_nor
U45  Net-_U37-Pad3_ Net-_U38-Pad3_ Net-_U45-Pad3_ d_nor
U19  Net-_U13-Pad1_ Net-_U10-Pad2_ Net-_U19-Pad3_ d_and
U20  Net-_U14-Pad1_ Net-_U10-Pad2_ Net-_U20-Pad3_ d_and
U21  Net-_U15-Pad1_ Net-_U10-Pad2_ Net-_U21-Pad3_ d_and
U22  Net-_U16-Pad1_ Net-_U10-Pad2_ Net-_U22-Pad3_ d_and
U33  Net-_U19-Pad3_ Net-_U20-Pad3_ Net-_U33-Pad3_ d_nor
U34  Net-_U21-Pad3_ Net-_U22-Pad3_ Net-_U34-Pad3_ d_nor
U39  Net-_U33-Pad3_ Net-_U33-Pad3_ Net-_U39-Pad3_ d_nor
U40  Net-_U34-Pad3_ Net-_U34-Pad3_ Net-_U40-Pad3_ d_nor
U46  Net-_U39-Pad3_ Net-_U40-Pad3_ Net-_U46-Pad3_ d_nor
U3  Net-_U2-Pad10_ Net-_U12-Pad1_ d_inverter
U12  Net-_U12-Pad1_ Net-_U12-Pad2_ d_inverter
U4  Net-_U2-Pad11_ Net-_U4-Pad2_ d_inverter
U6  Net-_U2-Pad12_ Net-_U13-Pad1_ d_inverter
U13  Net-_U13-Pad1_ Net-_U13-Pad2_ d_inverter
U7  Net-_U2-Pad13_ Net-_U14-Pad1_ d_inverter
U14  Net-_U14-Pad1_ Net-_U14-Pad2_ d_inverter
U8  Net-_U2-Pad14_ Net-_U15-Pad1_ d_inverter
U15  Net-_U15-Pad1_ Net-_U15-Pad2_ d_inverter
U9  Net-_U2-Pad15_ Net-_U16-Pad1_ d_inverter
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ d_inverter
U2  Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U2-Pad9_ Net-_U2-Pad10_ Net-_U2-Pad11_ Net-_U2-Pad12_ Net-_U2-Pad13_ Net-_U2-Pad14_ Net-_U2-Pad15_ Net-_U10-Pad1_ adc_bridge_8
U11  Net-_U1-Pad9_ Net-_U11-Pad2_ adc_bridge_1
U54  Net-_U52-Pad1_ Net-_U10-Pad2_ Net-_U52-Pad2_ d_nand
U52  Net-_U52-Pad1_ Net-_U52-Pad2_ Net-_U47-Pad3_ Net-_U45-Pad3_ Net-_U46-Pad3_ Net-_U1-Pad14_ Net-_U1-Pad13_ Net-_U1-Pad8_ Net-_U1-Pad7_ Net-_U1-Pad6_ dac_bridge_5
U51  Net-_U50-Pad3_ Net-_U50-Pad3_ Net-_U51-Pad3_ d_nand
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ PORT

.end
