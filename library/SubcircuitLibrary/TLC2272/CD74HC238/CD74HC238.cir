* D:\eSimWorkspace\CD74HC238\CD74HC238.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 05/20/25 16:21:10

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U2  Net-_U1-Pad1_ Net-_U2-Pad2_ d_buffer
U3  Net-_U1-Pad2_ Net-_U3-Pad2_ d_buffer
U4  Net-_U1-Pad3_ Net-_U4-Pad2_ d_buffer
X1  Net-_U1-Pad4_ Net-_X1-Pad2_ INVCMOS
X2  Net-_U1-Pad5_ Net-_X2-Pad2_ INVCMOS
U5  Net-_U1-Pad6_ Net-_U5-Pad2_ d_buffer
X4  Net-_U2-Pad2_ Net-_X11-Pad1_ INVCMOS
X5  Net-_U3-Pad2_ Net-_X11-Pad2_ INVCMOS
X6  Net-_U4-Pad2_ Net-_X10-Pad3_ INVCMOS
X3  Net-_X1-Pad2_ Net-_X2-Pad2_ Net-_U5-Pad2_ Net-_U10-Pad2_ 3_and
X7  Net-_X11-Pad1_ Net-_X11-Pad2_ Net-_X10-Pad3_ Net-_U6-Pad1_ 3_and
X8  Net-_U2-Pad2_ Net-_X11-Pad2_ Net-_X10-Pad3_ Net-_U7-Pad1_ 3_and
X9  Net-_X11-Pad1_ Net-_U3-Pad2_ Net-_X10-Pad3_ Net-_U8-Pad1_ 3_and
X10  Net-_U2-Pad2_ Net-_U3-Pad2_ Net-_X10-Pad3_ Net-_U9-Pad1_ 3_and
X11  Net-_X11-Pad1_ Net-_X11-Pad2_ Net-_U4-Pad2_ Net-_U10-Pad1_ 3_and
X12  Net-_U2-Pad2_ Net-_X11-Pad2_ Net-_U4-Pad2_ Net-_U12-Pad1_ 3_and
X13  Net-_X11-Pad1_ Net-_U3-Pad2_ Net-_U4-Pad2_ Net-_U13-Pad1_ 3_and
X14  Net-_U2-Pad2_ Net-_U3-Pad2_ Net-_U4-Pad2_ Net-_U11-Pad1_ 3_and
U6  Net-_U6-Pad1_ Net-_U10-Pad2_ Net-_U14-Pad1_ d_and
U7  Net-_U7-Pad1_ Net-_U10-Pad2_ Net-_U15-Pad1_ d_and
U8  Net-_U8-Pad1_ Net-_U10-Pad2_ Net-_U16-Pad1_ d_and
U9  Net-_U9-Pad1_ Net-_U10-Pad2_ Net-_U17-Pad1_ d_and
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ Net-_U10-Pad3_ d_and
U12  Net-_U12-Pad1_ Net-_U10-Pad2_ Net-_U12-Pad3_ d_and
U13  Net-_U13-Pad1_ Net-_U10-Pad2_ Net-_U13-Pad3_ d_and
U11  Net-_U11-Pad1_ Net-_U10-Pad2_ Net-_U11-Pad3_ d_and
U14  Net-_U14-Pad1_ Net-_U1-Pad15_ d_buffer
U15  Net-_U15-Pad1_ Net-_U1-Pad14_ d_buffer
U16  Net-_U16-Pad1_ Net-_U1-Pad13_ d_buffer
U17  Net-_U17-Pad1_ Net-_U1-Pad12_ d_buffer
U18  Net-_U10-Pad3_ Net-_U1-Pad11_ d_buffer
U19  Net-_U12-Pad3_ Net-_U1-Pad10_ d_buffer
U20  Net-_U13-Pad3_ Net-_U1-Pad9_ d_buffer
U21  Net-_U11-Pad3_ Net-_U1-Pad7_ d_buffer
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ ? Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ ? PORT

.end
