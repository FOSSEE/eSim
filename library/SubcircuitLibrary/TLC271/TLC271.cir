* C:\Users\HP\OneDrive\Documents\FOSSEE\eSim\library\SubcircuitLibrary\TLC271\TLC271.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/10/25 23:10:23

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
M1  Net-_M1-Pad1_ /INV Net-_D1-Pad2_ /VDD mosfet_p
M5  Net-_M1-Pad1_ /NON_INV Net-_D2-Pad2_ /VDD mosfet_p
M2  Net-_D1-Pad2_ Net-_D1-Pad2_ /OFFSET_NULL1 /VSS mosfet_n
M4  Net-_D2-Pad2_ Net-_D1-Pad2_ /OFFSET_NULL2 /VSS mosfet_n
R1  /OFFSET_NULL1 /VSS 3K
R2  /OFFSET_NULL2 /VSS 3K
D1  /VSS Net-_D1-Pad2_ eSim_Diode
M3  /VDD Net-_M10-Pad2_ Net-_M1-Pad1_ /VDD mosfet_p
M7  /VDD Net-_M10-Pad2_ Net-_M6-Pad1_ /VDD mosfet_p
M6  Net-_M6-Pad1_ Net-_D2-Pad2_ /VSS /VSS mosfet_n
R3  Net-_D2-Pad2_ Net-_C1-Pad1_ 10k
C1  Net-_C1-Pad1_ /OUT 30p
M8  Net-_M8-Pad1_ Net-_M6-Pad1_ /OUT /VSS mosfet_n
M9  /OUT Net-_D2-Pad2_ /VSS /VSS mosfet_n
D2  /VSS Net-_D2-Pad2_ eSim_Diode
R4  /VDD Net-_M8-Pad1_ 39k
M10  /VDD Net-_M10-Pad2_ Net-_M10-Pad2_ /VDD mosfet_p
M11  Net-_M11-Pad1_ Net-_M10-Pad2_ Net-_M10-Pad2_ /VDD mosfet_p
M13  Net-_M13-Pad1_ Net-_M10-Pad2_ Net-_M10-Pad2_ /VDD mosfet_p
M15  Net-_M13-Pad1_ Net-_M10-Pad2_ Net-_M12-Pad2_ /VDD mosfet_p
M14  /VDD Net-_M14-Pad2_ Net-_M13-Pad1_ /VDD mosfet_p
M17  Net-_M11-Pad1_ Net-_M10-Pad2_ Net-_M12-Pad2_ /VDD mosfet_p
M16  /VDD Net-_M16-Pad2_ Net-_M11-Pad1_ /VDD mosfet_p
M19  /VDD Net-_M10-Pad2_ Net-_M12-Pad2_ /VDD mosfet_p
M21  /VDD /BIAS_SELECT Net-_M14-Pad2_ /VDD mosfet_p
M23  /VDD Net-_M10-Pad2_ Net-_M16-Pad2_ /VDD mosfet_p
M27  /VDD Net-_M10-Pad2_ /BIAS_SELECT /VDD mosfet_p
M12  Net-_M10-Pad2_ Net-_M12-Pad2_ Net-_M12-Pad3_ /VSS mosfet_n
M18  Net-_M12-Pad2_ Net-_M12-Pad2_ /VSS /VSS mosfet_n
R5  Net-_M12-Pad3_ /VSS 100K
M24  /BIAS_SELECT /BIAS_SELECT Net-_M24-Pad3_ /VSS mosfet_n
M25  Net-_M24-Pad3_ Net-_M24-Pad3_ Net-_M25-Pad3_ /VSS mosfet_n
M26  Net-_M25-Pad3_ Net-_M12-Pad2_ /VSS /VSS mosfet_n
M22  Net-_M16-Pad2_ /BIAS_SELECT /VSS /VSS mosfet_n
M20  Net-_M14-Pad2_ Net-_M12-Pad2_ /VSS /VSS mosfet_n
U1  /VDD /INV /NON_INV /OFFSET_NULL1 /OFFSET_NULL2 /OUT /VSS /BIAS_SELECT PORT

.end
