.title KiCad schematic
Q4 Net-_Q14-Pad2_ Net-_D2-Pad2_ Net-_Q4-Pad3_ eSim_NPN
Q10 Net-_D5-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_PNP
R10 Net-_Q6-Pad1_ Net-_Q10-Pad2_ 3.2k
R11 Net-_Q10-Pad3_ Net-_Q12-Pad1_ 1.03k
R5 Net-_Q14-Pad2_ Net-_Q12-Pad1_ 834
Q7 Net-_Q10-Pad3_ Net-_Q14-Pad2_ Net-_Q10-Pad2_ eSim_NPN
R1 Net-_D2-Pad1_ Net-_Q12-Pad1_ 60k
U3 Net-_Q22-Pad3_ Net-_D1-Pad1_ Net-_Q12-Pad1_ Net-_D8-Pad2_ Net-_Q17-Pad3_ Net-_Q18-Pad2_ Net-_R15-Pad2_ Net-_Q15-Pad2_ Net-_Q12-Pad3_ Net-_D1-Pad1_ PORT
R4 Net-_Q6-Pad1_ Net-_Q1-Pad2_ 1.6k
Q1 Net-_D2-Pad2_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_PNP
D2 Net-_D2-Pad1_ Net-_D2-Pad2_ eSim_Diode
R2 Net-_Q1-Pad3_ Net-_Q12-Pad1_ 514
U2 Net-_D1-Pad2_ Net-_D2-Pad2_ zener
U1 Net-_D1-Pad1_ Net-_D2-Pad1_ zener
Q3 Net-_Q1-Pad3_ Net-_Q14-Pad2_ Net-_Q1-Pad2_ eSim_NPN
R3 Net-_D1-Pad1_ Net-_D1-Pad2_ 5k
D1 Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
Q2 Net-_D2-Pad2_ Net-_D1-Pad2_ Net-_D1-Pad1_ eSim_NPN
D4 Net-_D3-Pad2_ Net-_D4-Pad2_ eSim_Diode
D3 Net-_D3-Pad1_ Net-_D3-Pad2_ eSim_Diode
R8 Net-_D1-Pad1_ Net-_D4-Pad2_ 700
R7 Net-_D3-Pad1_ Net-_Q8-Pad2_ 2.67k
R6 Net-_Q8-Pad2_ Net-_Q4-Pad3_ 4.63k
Q5 Net-_Q12-Pad3_ Net-_D3-Pad1_ Net-_Q11-Pad2_ eSim_NPN
R9 Net-_D1-Pad1_ Net-_Q6-Pad3_ 623
Q6 Net-_Q6-Pad1_ Net-_Q11-Pad2_ Net-_Q6-Pad3_ eSim_NPN
Q9 Net-_Q12-Pad3_ Net-_Q8-Pad3_ Net-_Q11-Pad1_ eSim_NPN
Q8 Net-_Q12-Pad3_ Net-_Q8-Pad2_ Net-_Q8-Pad3_ eSim_NPN
R12 Net-_D1-Pad1_ Net-_Q11-Pad3_ 834
Q11 Net-_Q11-Pad1_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_NPN
Q12 Net-_Q12-Pad1_ Net-_D5-Pad1_ Net-_Q12-Pad3_ eSim_NPN
D5 Net-_D5-Pad1_ Net-_D5-Pad2_ eSim_Diode
R16 Net-_Q17-Pad2_ Net-_Q18-Pad2_ 1k
Q13 Net-_D5-Pad2_ Net-_Q13-Pad2_ Net-_Q11-Pad1_ eSim_NPN
Q15 Net-_D5-Pad2_ Net-_Q15-Pad2_ Net-_Q13-Pad2_ eSim_NPN
R17 Net-_D1-Pad1_ Net-_Q19-Pad3_ 410
Q19 Net-_Q18-Pad3_ Net-_Q11-Pad2_ Net-_Q19-Pad3_ eSim_NPN
R15 Net-_D5-Pad2_ Net-_R15-Pad2_ 50
Q14 Net-_Q14-Pad1_ Net-_Q14-Pad2_ Net-_Q14-Pad3_ eSim_NPN
R13 Net-_Q6-Pad1_ Net-_Q14-Pad3_ 1.6k
D6 Net-_D6-Pad1_ Net-_D6-Pad2_ eSim_Diode
Q20 Net-_Q12-Pad1_ Net-_D6-Pad1_ Net-_Q18-Pad1_ eSim_NPN
Q21 Net-_D6-Pad1_ Net-_Q17-Pad3_ Net-_Q18-Pad3_ eSim_NPN
D7 Net-_D6-Pad2_ Net-_D7-Pad2_ eSim_Diode
D8 Net-_D7-Pad2_ Net-_D8-Pad2_ eSim_Diode
Q22 Net-_Q12-Pad1_ Net-_Q18-Pad1_ Net-_Q22-Pad3_ eSim_NPN
Q17 Net-_D5-Pad1_ Net-_Q17-Pad2_ Net-_Q17-Pad3_ eSim_NPN
R14 Net-_Q14-Pad1_ Net-_Q12-Pad1_ 514
Q16 Net-_D6-Pad1_ Net-_Q14-Pad3_ Net-_Q14-Pad1_ eSim_PNP
Q18 Net-_Q18-Pad1_ Net-_Q18-Pad2_ Net-_Q18-Pad3_ eSim_NPN
.end
