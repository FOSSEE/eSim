* E:\ESIM\FOSSEE\eSim\library\SubcircuitLibrary\MAX7414\MAX7414.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 05/30/25 19:10:54

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
X1  ? Net-_C1-Pad1_ Net-_C2-Pad1_ Net-_U1-Pad4_ ? Net-_M7-Pad2_ Net-_U1-Pad3_ ? lm_741
R3  Net-_C1-Pad1_ Net-_M7-Pad2_ 10k
R2  Net-_C1-Pad1_ GND 10k
C2  Net-_C2-Pad1_ GND 0.05n
C1  Net-_C1-Pad1_ GND 0.001u
X2  ? Net-_C3-Pad1_ Net-_C4-Pad1_ Net-_U1-Pad4_ ? Net-_C5-Pad1_ Net-_U1-Pad3_ ? lm_741
R7  Net-_C3-Pad1_ Net-_C5-Pad1_ 13.82k
R6  Net-_C3-Pad1_ GND 10k
C4  Net-_C4-Pad1_ GND 0.05n
C5  Net-_C5-Pad1_ Net-_C5-Pad2_ 0.05n
C3  Net-_C3-Pad1_ GND 0.008u
X3  ? Net-_C6-Pad1_ Net-_C7-Pad1_ Net-_U1-Pad4_ ? Net-_C8-Pad1_ Net-_U1-Pad3_ ? lm_741
R11  Net-_C6-Pad1_ Net-_C8-Pad1_ 3.82k
R10  Net-_C6-Pad1_ GND 10k
C7  Net-_C7-Pad1_ GND 0.05n
C8  Net-_C8-Pad1_ Net-_C8-Pad2_ 0.05n
C6  Net-_C6-Pad1_ GND 0.01u
M1  Net-_C9-Pad1_ Net-_M1-Pad2_ Net-_M1-Pad2_ Net-_M1-Pad2_ eSim_MOS_N
M3  Net-_C2-Pad1_ Net-_M1-Pad2_ Net-_C9-Pad1_ Net-_M1-Pad2_ eSim_MOS_N
C9  Net-_C9-Pad1_ GND 0.05n
M7  Net-_C12-Pad1_ Net-_M7-Pad2_ Net-_M7-Pad2_ Net-_M7-Pad2_ eSim_MOS_N
M8  Net-_C5-Pad2_ Net-_M7-Pad2_ Net-_C12-Pad1_ Net-_M7-Pad2_ eSim_MOS_N
C12  Net-_C12-Pad1_ GND 0.005n
M9  Net-_C13-Pad1_ Net-_C5-Pad2_ Net-_C5-Pad2_ Net-_C5-Pad2_ eSim_MOS_N
M10  Net-_C4-Pad1_ Net-_C5-Pad2_ Net-_C13-Pad1_ Net-_C5-Pad2_ eSim_MOS_N
C13  Net-_C13-Pad1_ GND 0.005n
M2  Net-_C10-Pad1_ Net-_C5-Pad1_ Net-_C5-Pad1_ Net-_C5-Pad1_ eSim_MOS_N
M4  Net-_C8-Pad2_ Net-_C5-Pad1_ Net-_C10-Pad1_ Net-_C5-Pad1_ eSim_MOS_N
C10  Net-_C10-Pad1_ GND 0.05n
M5  Net-_C11-Pad1_ Net-_C8-Pad2_ Net-_C8-Pad2_ Net-_C8-Pad2_ eSim_MOS_N
M6  Net-_C7-Pad1_ Net-_C8-Pad2_ Net-_C11-Pad1_ Net-_C8-Pad2_ eSim_MOS_N
C11  Net-_C11-Pad1_ GND 0.05n
U1  ? Net-_M1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_C8-Pad1_ ? GND GND PORT

.end
