* D:\FOSSEE\eSim\library\SubcircuitLibrary\SN74278_1\SN74278_1.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 07/13/25 08:52:19

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U3  Net-_U3-Pad1_ /1 Net-_U3-Pad3_ d_and
U9  /3 /1 Net-_U8-Pad1_ d_and
U13  Net-_U13-Pad1_ /1 Net-_U13-Pad3_ d_and
U18  /2 /1 Net-_U17-Pad1_ d_and
U22  Net-_U22-Pad1_ /1 Net-_U22-Pad3_ d_and
U28  /13 /1 Net-_U26-Pad1_ d_and
U29  Net-_U29-Pad1_ /1 Net-_U29-Pad3_ d_and
U34  /12 /1 Net-_U33-Pad1_ d_and
U7  /3 Net-_U3-Pad1_ d_inverter
U16  /2 Net-_U13-Pad1_ d_inverter
U31  /12 Net-_U29-Pad1_ d_inverter
U25  /13 Net-_U22-Pad1_ d_inverter
U5  Net-_U11-Pad2_ Net-_U3-Pad3_ Net-_U2-Pad2_ d_nor
U8  Net-_U8-Pad1_ Net-_U2-Pad2_ Net-_U11-Pad2_ d_nor
U15  Net-_U15-Pad1_ Net-_U13-Pad3_ Net-_U11-Pad1_ d_nor
U17  Net-_U17-Pad1_ Net-_U11-Pad1_ Net-_U15-Pad1_ d_nor
U24  Net-_U24-Pad1_ Net-_U22-Pad3_ Net-_U14-Pad2_ d_nor
U26  Net-_U26-Pad1_ Net-_U14-Pad2_ Net-_U24-Pad1_ d_nor
U30  Net-_U30-Pad1_ Net-_U29-Pad3_ Net-_U14-Pad1_ d_nor
U33  Net-_U33-Pad1_ Net-_U14-Pad1_ Net-_U30-Pad1_ d_nor
U32  Net-_U30-Pad1_ /4 /10 d_nor
U12  Net-_U12-Pad1_ Net-_U11-Pad3_ Net-_U10-Pad1_ d_or
U11  Net-_U11-Pad1_ Net-_U11-Pad2_ Net-_U11-Pad3_ d_or
U14  Net-_U14-Pad1_ Net-_U14-Pad2_ Net-_U12-Pad1_ d_or
U4  Net-_U4-Pad1_ Net-_U2-Pad3_ Net-_U1-Pad1_ d_or
U2  Net-_U11-Pad1_ Net-_U2-Pad2_ Net-_U2-Pad3_ d_or
U6  Net-_U14-Pad1_ Net-_U14-Pad2_ Net-_U4-Pad1_ d_or
U1  Net-_U1-Pad1_ /4 /5 d_or
U10  Net-_U10-Pad1_ /4 /6 d_nor
U20  Net-_U20-Pad1_ Net-_U19-Pad3_ /8 d_nor
U19  Net-_U15-Pad1_ /4 Net-_U19-Pad3_ d_or
U21  Net-_U14-Pad1_ Net-_U14-Pad2_ Net-_U20-Pad1_ d_or
U23  /1 /2 /3 /4 /5 /6 ? /8 /9 /10 ? /12 /13 ? PORT
U35  Net-_U14-Pad1_ Net-_U24-Pad1_ Net-_U27-Pad1_ d_or
U27  Net-_U27-Pad1_ /4 /9 d_nor

.end
