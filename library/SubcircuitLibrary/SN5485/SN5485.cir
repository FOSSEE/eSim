* C:\Users\senba\Desktop\FOSSEE\eSim\library\SubcircuitLibrary\SN5485\SN5485.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 04/24/25 10:54:12

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U19  Net-_U18-Pad2_ Net-_U1-Pad1_ Net-_U19-Pad3_ d_and
X2  Net-_U14-Pad3_ Net-_U3-Pad3_ Net-_U1-Pad3_ Net-_U29-Pad1_ 3_and
X4  Net-_U15-Pad3_ Net-_U14-Pad3_ Net-_U10-Pad2_ Net-_U1-Pad8_ Net-_U28-Pad1_ 4_and
X10  Net-_U16-Pad3_ Net-_U15-Pad3_ Net-_U14-Pad3_ Net-_U12-Pad2_ Net-_U1-Pad10_ Net-_U27-Pad1_ 5_and
X9  Net-_U1-Pad7_ Net-_U17-Pad3_ Net-_U15-Pad3_ Net-_U16-Pad3_ Net-_U14-Pad3_ Net-_U26-Pad1_ 5_and
X8  Net-_U1-Pad6_ Net-_U17-Pad3_ Net-_U16-Pad3_ Net-_U15-Pad3_ Net-_U14-Pad3_ Net-_U25-Pad1_ 5_and
X7  Net-_U14-Pad3_ Net-_U15-Pad3_ Net-_U16-Pad3_ Net-_U17-Pad3_ Net-_U1-Pad6_ Net-_U31-Pad1_ 5_and
X6  Net-_U14-Pad3_ Net-_U15-Pad3_ Net-_U16-Pad3_ Net-_U17-Pad3_ Net-_U1-Pad5_ Net-_U24-Pad1_ 5_and
X5  Net-_U1-Pad11_ Net-_U12-Pad2_ Net-_U14-Pad3_ Net-_U15-Pad3_ Net-_U16-Pad3_ Net-_U23-Pad1_ 5_and
X3  Net-_U1-Pad9_ Net-_U10-Pad2_ Net-_U14-Pad3_ Net-_U15-Pad3_ Net-_U22-Pad1_ 4_and
X1  Net-_U1-Pad4_ Net-_U3-Pad3_ Net-_U14-Pad3_ Net-_U21-Pad1_ 3_and
U18  Net-_U1-Pad2_ Net-_U18-Pad2_ Net-_U18-Pad3_ d_and
X12  Net-_U20-Pad2_ Net-_U21-Pad2_ Net-_U22-Pad2_ Net-_U23-Pad2_ Net-_U24-Pad2_ Net-_U33-Pad1_ 5_and
U33  Net-_U33-Pad1_ Net-_U31-Pad2_ Net-_U1-Pad12_ d_and
U20  Net-_U18-Pad3_ Net-_U20-Pad2_ d_inverter
U21  Net-_U21-Pad1_ Net-_U21-Pad2_ d_inverter
U22  Net-_U22-Pad1_ Net-_U22-Pad2_ d_inverter
U23  Net-_U23-Pad1_ Net-_U23-Pad2_ d_inverter
U24  Net-_U24-Pad1_ Net-_U24-Pad2_ d_inverter
U31  Net-_U31-Pad1_ Net-_U31-Pad2_ d_inverter
X13  Net-_U25-Pad2_ Net-_U26-Pad2_ Net-_U27-Pad2_ Net-_U28-Pad2_ Net-_U29-Pad2_ Net-_U32-Pad1_ 5_and
U32  Net-_U32-Pad1_ Net-_U30-Pad2_ Net-_U1-Pad14_ d_and
U25  Net-_U25-Pad1_ Net-_U25-Pad2_ d_inverter
U26  Net-_U26-Pad1_ Net-_U26-Pad2_ d_inverter
U27  Net-_U27-Pad1_ Net-_U27-Pad2_ d_inverter
U28  Net-_U28-Pad1_ Net-_U28-Pad2_ d_inverter
U29  Net-_U29-Pad1_ Net-_U29-Pad2_ d_inverter
U30  Net-_U19-Pad3_ Net-_U30-Pad2_ d_inverter
U6  Net-_U1-Pad1_ Net-_U18-Pad2_ Net-_U14-Pad1_ d_and
U7  Net-_U18-Pad2_ Net-_U1-Pad2_ Net-_U14-Pad2_ d_and
U14  Net-_U14-Pad1_ Net-_U14-Pad2_ Net-_U14-Pad3_ d_nor
U15  Net-_U15-Pad1_ Net-_U15-Pad2_ Net-_U15-Pad3_ d_nor
U8  Net-_U1-Pad3_ Net-_U3-Pad3_ Net-_U15-Pad1_ d_and
U9  Net-_U3-Pad3_ Net-_U1-Pad4_ Net-_U15-Pad2_ d_and
U16  Net-_U10-Pad3_ Net-_U11-Pad3_ Net-_U16-Pad3_ d_nor
U10  Net-_U1-Pad8_ Net-_U10-Pad2_ Net-_U10-Pad3_ d_and
U11  Net-_U10-Pad2_ Net-_U1-Pad9_ Net-_U11-Pad3_ d_and
U12  Net-_U1-Pad10_ Net-_U12-Pad2_ Net-_U12-Pad3_ d_and
U13  Net-_U12-Pad2_ Net-_U1-Pad11_ Net-_U13-Pad3_ d_and
U17  Net-_U12-Pad3_ Net-_U13-Pad3_ Net-_U17-Pad3_ d_nor
U2  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U18-Pad2_ d_nand
U3  Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U3-Pad3_ d_nand
U4  Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U10-Pad2_ d_nand
U5  Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U12-Pad2_ d_nand
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ PORT
X11  Net-_U14-Pad3_ Net-_U15-Pad3_ Net-_U1-Pad6_ Net-_U16-Pad3_ Net-_U17-Pad3_ Net-_U1-Pad13_ 5_and

.end
