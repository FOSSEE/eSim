* C:\FOSSEE\eSim\library\SubcircuitLibrary\serial_d_4\serial_d_4.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 3/30/2025 6:50:47 PM

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U3  Net-_U1-Pad3_ Net-_U1-Pad1_ Net-_U1-Pad11_ Net-_U2-Pad2_ Net-_U3-Pad5_ ? d_dff
U5  Net-_U4-Pad5_ Net-_U1-Pad1_ Net-_U1-Pad11_ Net-_U2-Pad2_ Net-_U5-Pad5_ ? d_dff
U6  Net-_U5-Pad5_ Net-_U1-Pad1_ Net-_U1-Pad11_ Net-_U2-Pad2_ Net-_U1-Pad4_ ? d_dff
U7  Net-_U3-Pad5_ Net-_U1-Pad9_ Net-_U1-Pad11_ Net-_U1-Pad11_ Net-_U13-Pad1_ ? d_dff
U8  Net-_U4-Pad5_ Net-_U1-Pad9_ Net-_U1-Pad11_ Net-_U1-Pad11_ Net-_U14-Pad1_ ? d_dff
U9  Net-_U5-Pad5_ Net-_U1-Pad9_ Net-_U1-Pad11_ Net-_U1-Pad11_ Net-_U11-Pad1_ ? d_dff
U10  Net-_U1-Pad4_ Net-_U1-Pad9_ Net-_U1-Pad11_ Net-_U1-Pad11_ Net-_U10-Pad5_ ? d_dff
U13  Net-_U13-Pad1_ Net-_U11-Pad2_ Net-_U1-Pad7_ d_tristate
U14  Net-_U14-Pad1_ Net-_U11-Pad2_ Net-_U1-Pad8_ d_tristate
U11  Net-_U11-Pad1_ Net-_U11-Pad2_ Net-_U1-Pad5_ d_tristate
U12  Net-_U10-Pad5_ Net-_U11-Pad2_ Net-_U1-Pad6_ d_tristate
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ PORT
U15  Net-_U1-Pad10_ Net-_U11-Pad2_ d_inverter
U2  Net-_U1-Pad2_ Net-_U2-Pad2_ d_inverter
U4  Net-_U3-Pad5_ Net-_U1-Pad1_ Net-_U1-Pad11_ Net-_U2-Pad2_ Net-_U4-Pad5_ ? d_dff

.end
