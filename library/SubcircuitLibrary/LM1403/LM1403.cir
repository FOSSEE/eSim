* C:\FOSSEE\eSim\library\SubcircuitLibrary\LM1403\LM1403.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 05/26/25 18:04:17

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
Q1  Net-_C1-Pad2_ Net-_Q1-Pad2_ V- eSim_NPN
Q2  Net-_C1-Pad2_ Net-_C1-Pad1_ Net-_Q1-Pad2_ eSim_NPN
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 5p
Q4  Net-_C1-Pad1_ Net-_D1-Pad1_ V- eSim_NPN
D1  Net-_D1-Pad1_ V- eSim_Diode
R2  Net-_Q6-Pad3_ V- 12k
C3  Net-_C3-Pad1_ Net-_C1-Pad2_ 5p
Q5  Net-_D1-Pad1_ Net-_C3-Pad1_ Net-_Q3-Pad3_ eSim_PNP
Q3  Net-_C1-Pad1_ Net-_C2-Pad1_ Net-_Q3-Pad3_ eSim_PNP
C2  Net-_C2-Pad1_ Net-_C1-Pad1_ 5p
R1  Net-_Q11-Pad3_ Net-_Q3-Pad3_ 18k
Q6  Net-_Q6-Pad1_ Net-_D2-Pad1_ Net-_Q6-Pad3_ eSim_NPN
Q7  Net-_C3-Pad1_ Net-_Q7-Pad2_ Net-_I2-Pad2_ eSim_NPN
R3  Net-_Q11-Pad3_ Net-_Q6-Pad1_ 1.5k
R5  Net-_Q11-Pad3_ Net-_C2-Pad1_ 75k
I2  V- Net-_I2-Pad2_ dc
D2  Net-_D2-Pad1_ V- eSim_Diode
Q10  Net-_D2-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_PNP
R12  Net-_Q10-Pad2_ V- 55k
R11  Net-_R10-Pad2_ Net-_Q10-Pad2_ 50k
R4  Net-_Q6-Pad1_ Net-_C3-Pad1_ 75k
Q8  Net-_C2-Pad1_ Net-_Q8-Pad2_ Net-_I2-Pad2_ eSim_NPN
R8  Net-_Q7-Pad2_ Net-_Q10-Pad3_ 33k
R7  Net-_Q8-Pad2_ Net-_Q7-Pad2_ 3k
R6  VOUT Net-_Q8-Pad2_ 33k
Q9  Net-_C1-Pad2_ Net-_Q12-Pad3_ VOUT eSim_NPN
R10  Net-_Q12-Pad3_ Net-_R10-Pad2_ 20
R9  Net-_Q11-Pad3_ Net-_Q12-Pad3_ 20k
Q12  V+ Net-_Q11-Pad3_ Net-_Q12-Pad3_ eSim_NPN
Q11  V+ Net-_C1-Pad2_ Net-_Q11-Pad3_ eSim_NPN
I1  Net-_C1-Pad2_ V+ dc
U1  VOUT V- V+ PORT

.end
