* C:\FOSSEE\eSim\library\SubcircuitLibrary\LM109_NEW_SUB\LM109_NEW_SUB.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 10/02/24 19:57:59

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
J1  Net-_J1-Pad1_ Net-_D1-Pad1_ Net-_J1-Pad3_ jfet_n
D1  Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
Q2  Net-_J1-Pad1_ Net-_Q10-Pad1_ Net-_J1-Pad3_ eSim_NPN
R1  Net-_Q3-Pad3_ Net-_D1-Pad1_ 450
Q3  Net-_J1-Pad3_ Net-_Q3-Pad2_ Net-_Q3-Pad3_ eSim_NPN
Q6  Net-_J1-Pad3_ Net-_J1-Pad3_ Net-_Q6-Pad3_ eSim_NPN
R4  Net-_J1-Pad3_ Net-_Q6-Pad3_ 3k
R2  Net-_Q6-Pad3_ Net-_Q3-Pad2_ 2.4k
R3  Net-_Q3-Pad2_ Net-_Q5-Pad1_ 25
Q5  Net-_Q5-Pad1_ Net-_Q3-Pad3_ Net-_D1-Pad1_ eSim_NPN
Q8  Net-_Q11-Pad3_ Net-_Q5-Pad1_ Net-_Q8-Pad3_ eSim_NPN
R5  Net-_Q8-Pad3_ Net-_D1-Pad1_ 12.1k
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad1_ Net-_Q10-Pad3_ eSim_NPN
Q11  Net-_Q10-Pad3_ Net-_Q10-Pad3_ Net-_Q11-Pad3_ eSim_NPN
R6  Net-_Q11-Pad3_ Net-_C1-Pad2_ 24k
Q9  Net-_C1-Pad2_ Net-_Q8-Pad3_ Net-_Q9-Pad3_ eSim_NPN
R7  Net-_Q9-Pad3_ Net-_D1-Pad1_ 1k
Q13  Net-_C1-Pad1_ Net-_C1-Pad2_ Net-_Q13-Pad3_ eSim_NPN
Q15  Net-_Q15-Pad1_ Net-_Q15-Pad1_ Net-_D1-Pad1_ eSim_NPN
R10  Net-_Q13-Pad3_ Net-_Q15-Pad1_ 4k
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 30pF
U1  Net-_D2-Pad1_ Net-_Q12-Pad2_ zener
Q12  Net-_D1-Pad2_ Net-_Q12-Pad2_ Net-_Q12-Pad3_ eSim_NPN
R8  Net-_Q12-Pad3_ Net-_Q14-Pad2_ 3.1k
R9  Net-_Q14-Pad2_ Net-_D1-Pad1_ 200
Q14  Net-_Q14-Pad1_ Net-_Q14-Pad2_ Net-_D1-Pad1_ eSim_NPN
Q16  Net-_Q14-Pad1_ Net-_D5-Pad2_ Net-_Q10-Pad1_ eSim_NPN
U2  Net-_D4-Pad1_ Net-_R11-Pad2_ zener
R11  Net-_D1-Pad2_ Net-_R11-Pad2_ 10k
R12  Net-_Q20-Pad3_ Net-_D5-Pad2_ 130
R13  Net-_Q14-Pad1_ Net-_C1-Pad1_ 4k
Q17  Net-_C1-Pad1_ Net-_Q13-Pad3_ Net-_D1-Pad1_ eSim_NPN
Q18  Net-_D1-Pad1_ Net-_C1-Pad1_ Net-_Q14-Pad1_ eSim_PNP
Q20  Net-_D1-Pad2_ Net-_Q19-Pad3_ Net-_Q20-Pad3_ eSim_NPN
Q19  Net-_D1-Pad2_ Net-_Q14-Pad1_ Net-_Q19-Pad3_ eSim_NPN
R14  Net-_Q20-Pad3_ Net-_Q19-Pad3_ 2k
R15  Net-_Q10-Pad1_ Net-_Q20-Pad3_ 0.3
R16  Net-_R16-Pad1_ Net-_Q10-Pad1_ 4
U3  Net-_D6-Pad1_ Net-_R16-Pad1_ zener
D2  Net-_D2-Pad1_ Net-_D2-Pad2_ eSim_Diode
D3  Net-_D2-Pad2_ Net-_D1-Pad1_ eSim_Diode
D4  Net-_D4-Pad1_ Net-_D4-Pad2_ eSim_Diode
D5  Net-_D4-Pad2_ Net-_D5-Pad2_ eSim_Diode
D6  Net-_D6-Pad1_ Net-_D6-Pad2_ eSim_Diode
D7  Net-_D6-Pad2_ Net-_D1-Pad1_ eSim_Diode
Q1  Net-_J1-Pad1_ Net-_J1-Pad1_ Net-_D1-Pad2_ eSim_PNP
Q4  Net-_Q14-Pad1_ Net-_J1-Pad1_ Net-_D1-Pad2_ eSim_PNP
Q7  Net-_Q12-Pad2_ Net-_J1-Pad1_ Net-_D1-Pad2_ eSim_PNP
U4  Net-_D1-Pad2_ Net-_Q10-Pad1_ Net-_D1-Pad1_ PORT

.end
