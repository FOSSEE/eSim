.title KiCad schematic
U60 Net-_U52-Pad3_ Net-_U53-Pad3_ Net-_U60-Pad3_ d_and
U52 Net-_U35-Pad2_ Net-_U36-Pad2_ Net-_U52-Pad3_ d_xnor
U53 Net-_U37-Pad2_ Net-_U38-Pad2_ Net-_U53-Pad3_ d_xnor
U1 Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ Net-_U1-Pad16_ Net-_U1-Pad17_ Net-_U1-Pad18_ PORT
U36 Net-_U1-Pad2_ Net-_U36-Pad2_ d_inverter
U35 Net-_U1-Pad1_ Net-_U35-Pad2_ d_inverter
U38 Net-_U1-Pad4_ Net-_U38-Pad2_ d_inverter
U37 Net-_U1-Pad3_ Net-_U37-Pad2_ d_inverter
U39 Net-_U1-Pad5_ Net-_U39-Pad2_ d_inverter
U40 Net-_U1-Pad6_ Net-_U40-Pad2_ d_inverter
U42 Net-_U1-Pad8_ Net-_U42-Pad2_ d_inverter
U41 Net-_U1-Pad7_ Net-_U41-Pad2_ d_inverter
U66 Net-_U64-Pad3_ Net-_U65-Pad3_ Net-_U66-Pad3_ d_and
U64 Net-_U60-Pad3_ Net-_U61-Pad3_ Net-_U64-Pad3_ d_and
U67 Net-_U66-Pad3_ Net-_U51-Pad2_ Net-_U67-Pad3_ d_and
U68 Net-_U67-Pad3_ Net-_U1-Pad18_ d_inverter
U54 Net-_U39-Pad2_ Net-_U40-Pad2_ Net-_U54-Pad3_ d_xnor
U61 Net-_U54-Pad3_ Net-_U55-Pad3_ Net-_U61-Pad3_ d_and
U55 Net-_U41-Pad2_ Net-_U42-Pad2_ Net-_U55-Pad3_ d_xnor
U56 Net-_U43-Pad2_ Net-_U44-Pad2_ Net-_U56-Pad3_ d_xnor
U57 Net-_U45-Pad2_ Net-_U46-Pad2_ Net-_U57-Pad3_ d_xnor
U44 Net-_U1-Pad10_ Net-_U44-Pad2_ d_inverter
U45 Net-_U1-Pad11_ Net-_U45-Pad2_ d_inverter
U43 Net-_U1-Pad9_ Net-_U43-Pad2_ d_inverter
U50 Net-_U1-Pad16_ Net-_U50-Pad2_ d_inverter
U51 Net-_U1-Pad17_ Net-_U51-Pad2_ d_buffer
U59 Net-_U49-Pad2_ Net-_U50-Pad2_ Net-_U59-Pad3_ d_xnor
U65 Net-_U62-Pad3_ Net-_U63-Pad3_ Net-_U65-Pad3_ d_and
U63 Net-_U58-Pad3_ Net-_U59-Pad3_ Net-_U63-Pad3_ d_and
U46 Net-_U1-Pad12_ Net-_U46-Pad2_ d_inverter
U47 Net-_U1-Pad13_ Net-_U47-Pad2_ d_inverter
U58 Net-_U47-Pad2_ Net-_U48-Pad2_ Net-_U58-Pad3_ d_xnor
U48 Net-_U1-Pad14_ Net-_U48-Pad2_ d_inverter
U49 Net-_U1-Pad15_ Net-_U49-Pad2_ d_inverter
U62 Net-_U56-Pad3_ Net-_U57-Pad3_ Net-_U62-Pad3_ d_and
.end
