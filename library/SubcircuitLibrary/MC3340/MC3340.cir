* C:\FOSSEE\eSim\library\SubcircuitLibrary\MC3340\MC3340.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/05/25 17:24:07

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
R1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ 5.1K
R2  Net-_Q1-Pad2_ GND 4.7K
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
R3  Net-_Q1-Pad3_ Net-_Q2-Pad2_ 750
R4  Net-_Q2-Pad2_ GND 10K
Q2  Net-_Q1-Pad1_ Net-_Q2-Pad2_ Net-_Q2-Pad3_ eSim_NPN
R6  Net-_Q1-Pad3_ Net-_Q3-Pad2_ 750
R7  Net-_Q3-Pad2_ Net-_R7-Pad2_ 3.9K
Q3  Net-_Q1-Pad1_ Net-_Q3-Pad2_ Net-_Q3-Pad3_ eSim_NPN
R8  Net-_Q1-Pad1_ Net-_R5-Pad2_ 5.1K
Q4  Net-_Q1-Pad1_ Net-_Q3-Pad3_ Net-_Q4-Pad3_ eSim_NPN
Q6  Net-_Q10-Pad2_ Net-_Q2-Pad3_ Net-_Q4-Pad3_ eSim_NPN
Q7  Net-_Q1-Pad1_ Net-_Q2-Pad3_ Net-_Q7-Pad3_ eSim_NPN
Q9  Net-_Q9-Pad1_ Net-_Q3-Pad3_ Net-_Q7-Pad3_ eSim_NPN
R13  Net-_Q1-Pad1_ Net-_Q9-Pad1_ 6.2k
Q10  Net-_Q1-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
R15  Net-_Q10-Pad3_ GND 5.1k
R16  Net-_Q1-Pad1_ Net-_D1-Pad1_ 5.1k
R11  Net-_Q2-Pad3_ GND 5.1k
R14  Net-_Q3-Pad3_ GND 5.1k
R18  Net-_R18-Pad1_ Net-_Q10-Pad3_ 200
D1  Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
R17  Net-_D1-Pad2_ GND 510
Q8  Net-_Q7-Pad3_ Net-_D1-Pad1_ Net-_Q8-Pad3_ eSim_NPN
R12  Net-_Q8-Pad3_ GND 1.5k
Q5  Net-_Q4-Pad3_ Net-_Q5-Pad2_ Net-_Q5-Pad3_ eSim_NPN
R10  Net-_Q5-Pad3_ GND 1.3k
R5  Net-_Q5-Pad2_ Net-_R5-Pad2_ 20K
R9  Net-_R5-Pad2_ GND 510
U1  Net-_Q5-Pad2_ Net-_R7-Pad2_ ? ? ? Net-_Q10-Pad2_ Net-_R18-Pad1_ Net-_Q1-Pad1_ PORT

.end
