* C:\FOSSEE\eSim\library\SubcircuitLibrary\SN7407\SN7407.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 07/06/25 11:06:26

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_D1-Pad2_ eSim_NPN
Q2  Net-_Q2-Pad1_ Net-_Q1-Pad1_ Net-_Q2-Pad3_ eSim_NPN
Q3  Net-_Q3-Pad1_ Net-_Q3-Pad2_ Net-_D1-Pad1_ eSim_NPN
Q4  Net-_Q4-Pad1_ Net-_Q3-Pad1_ Net-_D1-Pad1_ eSim_NPN
D1  Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
R1  Net-_R1-Pad1_ Net-_Q1-Pad2_ 6K
R2  Net-_R1-Pad1_ Net-_Q2-Pad1_ 3.4K
R3  Net-_Q2-Pad3_ Net-_Q3-Pad2_ 100
R4  Net-_Q3-Pad2_ Net-_D1-Pad1_ 1K
R5  Net-_R1-Pad1_ Net-_Q3-Pad1_ 1.6K
Q5  Net-_Q5-Pad1_ Net-_Q5-Pad2_ Net-_D2-Pad2_ eSim_NPN
Q6  Net-_Q6-Pad1_ Net-_Q5-Pad1_ Net-_Q6-Pad3_ eSim_NPN
Q7  Net-_Q7-Pad1_ Net-_Q7-Pad2_ Net-_D1-Pad1_ eSim_NPN
Q8  Net-_Q8-Pad1_ Net-_Q7-Pad1_ Net-_D1-Pad1_ eSim_NPN
D2  Net-_D1-Pad1_ Net-_D2-Pad2_ eSim_Diode
R6  Net-_R1-Pad1_ Net-_Q5-Pad2_ 6K
R7  Net-_R1-Pad1_ Net-_Q6-Pad1_ 3.4K
R8  Net-_Q6-Pad3_ Net-_Q7-Pad2_ 100
R9  Net-_Q7-Pad2_ Net-_D1-Pad1_ 1K
R10  Net-_R1-Pad1_ Net-_Q7-Pad1_ 1.6K
Q9  Net-_Q11-Pad2_ Net-_Q9-Pad2_ Net-_D3-Pad2_ eSim_NPN
Q11  Net-_Q11-Pad1_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_NPN
Q13  Net-_Q13-Pad1_ Net-_Q13-Pad2_ Net-_D1-Pad1_ eSim_NPN
Q15  Net-_Q15-Pad1_ Net-_Q13-Pad1_ Net-_D1-Pad1_ eSim_NPN
D3  Net-_D1-Pad1_ Net-_D3-Pad2_ eSim_Diode
R11  Net-_R1-Pad1_ Net-_Q9-Pad2_ 6K
R13  Net-_R1-Pad1_ Net-_Q11-Pad1_ 3.4K
R14  Net-_Q11-Pad3_ Net-_Q13-Pad2_ 100
R15  Net-_Q13-Pad2_ Net-_D1-Pad1_ 1K
R19  Net-_R1-Pad1_ Net-_Q13-Pad1_ 1.6K
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_D4-Pad2_ eSim_NPN
Q12  Net-_Q12-Pad1_ Net-_Q10-Pad1_ Net-_Q12-Pad3_ eSim_NPN
Q14  Net-_Q14-Pad1_ Net-_Q14-Pad2_ Net-_D1-Pad1_ eSim_NPN
Q16  Net-_Q16-Pad1_ Net-_Q14-Pad1_ Net-_D1-Pad1_ eSim_NPN
D4  Net-_D1-Pad1_ Net-_D4-Pad2_ eSim_Diode
R12  Net-_R1-Pad1_ Net-_Q10-Pad2_ 6K
R16  Net-_R1-Pad1_ Net-_Q12-Pad1_ 3.4K
R17  Net-_Q12-Pad3_ Net-_Q14-Pad2_ 100
R18  Net-_Q14-Pad2_ Net-_D1-Pad1_ 1K
R20  Net-_R1-Pad1_ Net-_Q14-Pad1_ 1.6K
Q17  Net-_Q17-Pad1_ Net-_Q17-Pad2_ Net-_D5-Pad2_ eSim_NPN
Q19  Net-_Q19-Pad1_ Net-_Q17-Pad1_ Net-_Q19-Pad3_ eSim_NPN
Q21  Net-_Q21-Pad1_ Net-_Q21-Pad2_ Net-_D1-Pad1_ eSim_NPN
Q23  Net-_Q23-Pad1_ Net-_Q21-Pad1_ Net-_D1-Pad1_ eSim_NPN
D5  Net-_D1-Pad1_ Net-_D5-Pad2_ eSim_Diode
R21  Net-_R1-Pad1_ Net-_Q17-Pad2_ 6K
R23  Net-_R1-Pad1_ Net-_Q19-Pad1_ 3.4K
R24  Net-_Q19-Pad3_ Net-_Q21-Pad2_ 100
R25  Net-_Q21-Pad2_ Net-_D1-Pad1_ 1K
R29  Net-_R1-Pad1_ Net-_Q21-Pad1_ 1.6K
Q18  Net-_Q18-Pad1_ Net-_Q18-Pad2_ Net-_D6-Pad2_ eSim_NPN
Q20  Net-_Q20-Pad1_ Net-_Q18-Pad1_ Net-_Q20-Pad3_ eSim_NPN
Q22  Net-_Q22-Pad1_ Net-_Q22-Pad2_ Net-_D1-Pad1_ eSim_NPN
Q24  Net-_Q24-Pad1_ Net-_Q22-Pad1_ Net-_D1-Pad1_ eSim_NPN
D6  Net-_D1-Pad1_ Net-_D6-Pad2_ eSim_Diode
R22  Net-_R1-Pad1_ Net-_Q18-Pad2_ 6K
R26  Net-_R1-Pad1_ Net-_Q20-Pad1_ 3.4K
R27  Net-_Q20-Pad3_ Net-_Q22-Pad2_ 100
R28  Net-_Q22-Pad2_ Net-_D1-Pad1_ 1K
R30  Net-_R1-Pad1_ Net-_Q22-Pad1_ 1.6K
U1  Net-_D1-Pad2_ Net-_Q4-Pad1_ Net-_D2-Pad2_ Net-_Q8-Pad1_ Net-_D3-Pad2_ Net-_Q15-Pad1_ Net-_D1-Pad1_ Net-_Q16-Pad1_ Net-_D4-Pad2_ Net-_Q23-Pad1_ Net-_D5-Pad2_ Net-_Q24-Pad1_ Net-_D6-Pad2_ Net-_R1-Pad1_ PORT

.end
