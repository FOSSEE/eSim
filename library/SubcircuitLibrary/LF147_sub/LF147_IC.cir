* D:\FOSSEE\eSim\library\SubcircuitLibrary\LF147_IC\LF147_IC.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 07/12/24 14:21:00

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
I1  Net-_I1-Pad1_ Net-_I1-Pad2_ 80u
I3  Net-_I1-Pad1_ Net-_D3-Pad1_ 400u
J1  Net-_I1-Pad2_ Net-_J1-Pad2_ Net-_D1-Pad1_ jfet_p
J3  Net-_I1-Pad2_ Net-_J3-Pad2_ Net-_C1-Pad2_ jfet_p
D1  Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
R1  Net-_D1-Pad2_ Net-_Q11-Pad3_ 5k
Q1  Net-_C1-Pad2_ Net-_D1-Pad1_ Net-_Q1-Pad3_ eSim_NPN
R3  Net-_Q1-Pad3_ Net-_Q11-Pad3_ 2k
D3  Net-_D3-Pad1_ Net-_D3-Pad2_ eSim_Diode
D4  Net-_D3-Pad2_ Net-_C1-Pad1_ eSim_Diode
Q3  Net-_C1-Pad1_ Net-_C1-Pad2_ Net-_Q11-Pad3_ eSim_NPN
Q5  Net-_I1-Pad1_ Net-_D3-Pad1_ Net-_Q5-Pad3_ eSim_NPN
Q6  Net-_Q11-Pad3_ Net-_C1-Pad1_ Net-_Q5-Pad3_ eSim_PNP
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 10p
I5  Net-_I1-Pad1_ Net-_I5-Pad2_ 80u
I7  Net-_I1-Pad1_ Net-_D9-Pad1_ 400u
J5  Net-_I5-Pad2_ Net-_J5-Pad2_ Net-_D7-Pad1_ jfet_p
J7  Net-_I5-Pad2_ Net-_J7-Pad2_ Net-_C3-Pad2_ jfet_p
D7  Net-_D7-Pad1_ Net-_D7-Pad2_ eSim_Diode
R5  Net-_D7-Pad2_ Net-_Q11-Pad3_ 5k
Q9  Net-_C3-Pad2_ Net-_D7-Pad1_ Net-_Q9-Pad3_ eSim_NPN
R7  Net-_Q9-Pad3_ Net-_Q11-Pad3_ 2k
D9  Net-_D9-Pad1_ Net-_D10-Pad1_ eSim_Diode
D10  Net-_D10-Pad1_ Net-_C3-Pad1_ eSim_Diode
Q11  Net-_C3-Pad1_ Net-_C3-Pad2_ Net-_Q11-Pad3_ eSim_NPN
Q13  Net-_I1-Pad1_ Net-_D9-Pad1_ Net-_Q13-Pad3_ eSim_NPN
Q14  Net-_Q11-Pad3_ Net-_C3-Pad1_ Net-_Q13-Pad3_ eSim_PNP
C3  Net-_C3-Pad1_ Net-_C3-Pad2_ 10p
I2  Net-_I1-Pad1_ Net-_I2-Pad2_ 80u
I4  Net-_I1-Pad1_ Net-_D5-Pad1_ 400u
J2  Net-_I2-Pad2_ Net-_J2-Pad2_ Net-_D2-Pad1_ jfet_p
J4  Net-_I2-Pad2_ Net-_J4-Pad2_ Net-_C2-Pad2_ jfet_p
D2  Net-_D2-Pad1_ Net-_D2-Pad2_ eSim_Diode
R2  Net-_D2-Pad2_ Net-_Q11-Pad3_ 5k
Q2  Net-_C2-Pad2_ Net-_D2-Pad1_ Net-_Q2-Pad3_ eSim_NPN
R4  Net-_Q2-Pad3_ Net-_Q11-Pad3_ 2k
D5  Net-_D5-Pad1_ Net-_D5-Pad2_ eSim_Diode
D6  Net-_D5-Pad2_ Net-_C2-Pad1_ eSim_Diode
Q4  Net-_C2-Pad1_ Net-_C2-Pad2_ Net-_Q11-Pad3_ eSim_NPN
Q7  Net-_I1-Pad1_ Net-_D5-Pad1_ Net-_Q7-Pad3_ eSim_NPN
Q8  Net-_Q11-Pad3_ Net-_C2-Pad1_ Net-_Q7-Pad3_ eSim_PNP
C2  Net-_C2-Pad1_ Net-_C2-Pad2_ 10p
I6  Net-_I1-Pad1_ Net-_I6-Pad2_ 80u
I8  Net-_I1-Pad1_ Net-_D11-Pad1_ 400u
J6  Net-_I6-Pad2_ Net-_J6-Pad2_ Net-_D8-Pad1_ jfet_p
J8  Net-_I6-Pad2_ Net-_J8-Pad2_ Net-_C4-Pad2_ jfet_p
D8  Net-_D8-Pad1_ Net-_D8-Pad2_ eSim_Diode
R6  Net-_D8-Pad2_ Net-_Q11-Pad3_ 5k
Q10  Net-_C4-Pad2_ Net-_D8-Pad1_ Net-_Q10-Pad3_ eSim_NPN
R8  Net-_Q10-Pad3_ Net-_Q11-Pad3_ 2k
D11  Net-_D11-Pad1_ Net-_D11-Pad2_ eSim_Diode
D12  Net-_D11-Pad2_ Net-_C4-Pad1_ eSim_Diode
Q12  Net-_C4-Pad1_ Net-_C4-Pad2_ Net-_Q11-Pad3_ eSim_NPN
Q15  Net-_I1-Pad1_ Net-_D11-Pad1_ Net-_Q15-Pad3_ eSim_NPN
Q16  Net-_Q11-Pad3_ Net-_C4-Pad1_ Net-_Q15-Pad3_ eSim_PNP
C4  Net-_C4-Pad1_ Net-_C4-Pad2_ 10p
U1  Net-_Q5-Pad3_ Net-_J1-Pad2_ Net-_J3-Pad2_ Net-_I1-Pad1_ Net-_J4-Pad2_ Net-_J2-Pad2_ Net-_Q7-Pad3_ Net-_Q15-Pad3_ Net-_J6-Pad2_ Net-_J8-Pad2_ Net-_Q11-Pad3_ Net-_J7-Pad2_ Net-_J5-Pad2_ Net-_Q13-Pad3_ PORT

.end
