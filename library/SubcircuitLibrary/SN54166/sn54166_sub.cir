.title KiCad schematic
U18 Net-_U17-Pad2_ Net-_U13-Pad3_ Net-_U12-Pad3_ unconnected-_U18-Pad4_ d5 d4 unconnected-_U18-Pad7_ d_srff
U13 Net-_U13-Pad1_ Net-_U13-Pad2_ Net-_U13-Pad3_ d_nor
U5 Net-_U11-Pad1_ Net-_U1-Pad5_ Net-_U13-Pad2_ d_and
U1 Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ unconnected-_U1-Pad8_ d5 Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ d8 Net-_U1-Pad14_ Net-_U1-Pad15_ unconnected-_U1-Pad16_ PORT
U12 Net-_U1-Pad7_ Net-_U1-Pad6_ Net-_U12-Pad3_ d_nor
U14 Net-_U14-Pad1_ Net-_U14-Pad2_ Net-_U14-Pad3_ d_nor
U4 d3 Net-_U10-Pad2_ Net-_U13-Pad1_ d_and
U22 Net-_U21-Pad2_ Net-_U15-Pad3_ Net-_U12-Pad3_ unconnected-_U22-Pad4_ d5 d2 unconnected-_U22-Pad7_ d_srff
U20 Net-_U19-Pad2_ Net-_U14-Pad3_ Net-_U12-Pad3_ unconnected-_U20-Pad4_ d5 d3 unconnected-_U20-Pad7_ d_srff
U6 d2 Net-_U10-Pad2_ Net-_U14-Pad1_ d_and
U7 Net-_U11-Pad1_ Net-_U1-Pad4_ Net-_U14-Pad2_ d_and
U2 Net-_U1-Pad15_ Net-_U11-Pad1_ d_inverter
U3 Net-_U11-Pad1_ Net-_U10-Pad2_ d_inverter
U11 Net-_U11-Pad1_ Net-_U1-Pad2_ Net-_U11-Pad3_ d_and
U10 Net-_U1-Pad1_ Net-_U10-Pad2_ Net-_U10-Pad3_ d_and
U16 Net-_U10-Pad3_ Net-_U11-Pad3_ Net-_U16-Pad3_ d_nor
U8 d1 Net-_U10-Pad2_ Net-_U15-Pad1_ d_and
U15 Net-_U15-Pad1_ Net-_U15-Pad2_ Net-_U15-Pad3_ d_nor
U9 Net-_U11-Pad1_ Net-_U1-Pad3_ Net-_U15-Pad2_ d_and
U23 Net-_U16-Pad3_ Net-_U23-Pad2_ d_inverter
U24 Net-_U23-Pad2_ Net-_U16-Pad3_ Net-_U12-Pad3_ unconnected-_U24-Pad4_ d5 d1 unconnected-_U24-Pad7_ d_srff
U21 Net-_U15-Pad3_ Net-_U21-Pad2_ d_inverter
U19 Net-_U14-Pad3_ Net-_U19-Pad2_ d_inverter
U30 Net-_U11-Pad1_ Net-_U1-Pad11_ Net-_U30-Pad3_ d_and
U29 d5 Net-_U10-Pad2_ Net-_U29-Pad3_ d_and
U35 Net-_U29-Pad3_ Net-_U30-Pad3_ Net-_U35-Pad3_ d_nor
U42 Net-_U41-Pad2_ Net-_U35-Pad3_ Net-_U12-Pad3_ unconnected-_U42-Pad4_ d5 d6 unconnected-_U42-Pad7_ d_srff
U39 Net-_U34-Pad3_ Net-_U39-Pad2_ d_inverter
U44 Net-_U43-Pad2_ Net-_U36-Pad3_ Net-_U12-Pad3_ unconnected-_U44-Pad4_ d5 d5 unconnected-_U44-Pad7_ d_srff
U41 Net-_U35-Pad3_ Net-_U41-Pad2_ d_inverter
U43 Net-_U36-Pad3_ Net-_U43-Pad2_ d_inverter
U36 Net-_U31-Pad3_ Net-_U32-Pad3_ Net-_U36-Pad3_ d_nor
U17 Net-_U13-Pad3_ Net-_U17-Pad2_ d_inverter
U33 Net-_U25-Pad3_ Net-_U26-Pad3_ Net-_U33-Pad3_ d_nor
U25 d7 Net-_U10-Pad2_ Net-_U25-Pad3_ d_and
U26 Net-_U11-Pad1_ Net-_U1-Pad14_ Net-_U26-Pad3_ d_and
U38 Net-_U37-Pad2_ Net-_U33-Pad3_ Net-_U12-Pad3_ unconnected-_U38-Pad4_ d5 d8 unconnected-_U38-Pad7_ d_srff
U37 Net-_U33-Pad3_ Net-_U37-Pad2_ d_inverter
U28 Net-_U11-Pad1_ Net-_U1-Pad12_ Net-_U28-Pad3_ d_and
U27 d6 Net-_U10-Pad2_ Net-_U27-Pad3_ d_and
U34 Net-_U27-Pad3_ Net-_U28-Pad3_ Net-_U34-Pad3_ d_nor
U40 Net-_U39-Pad2_ Net-_U34-Pad3_ Net-_U12-Pad3_ unconnected-_U40-Pad4_ d5 d7 unconnected-_U40-Pad7_ d_srff
U32 Net-_U11-Pad1_ Net-_U1-Pad10_ Net-_U32-Pad3_ d_and
U31 d4 Net-_U10-Pad2_ Net-_U31-Pad3_ d_and
.end
