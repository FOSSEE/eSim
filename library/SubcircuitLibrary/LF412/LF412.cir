.title KiCad schematic
R6 Net-_C1-Pad2_ Net-_Q14-Pad2_ 6k
Q13 Net-_C1-Pad2_ Net-_Q13-Pad2_ Net-_Q13-Pad3_ eSim_NPN
D2 Net-_D2-Pad1_ Net-_D2-Pad2_ eSim_Diode
R7 Net-_D2-Pad2_ Net-_Q16-Pad3_ 160
R5 Net-_D2-Pad2_ Net-_Q13-Pad3_ 30
Q16 Net-_C1-Pad1_ Net-_D3-Pad1_ Net-_Q16-Pad3_ eSim_NPN
Q18 Net-_D3-Pad1_ Net-_Q18-Pad2_ Net-_Q17-Pad3_ eSim_PNP
Q8 Net-_Q13-Pad2_ Net-_D2-Pad1_ Net-_D2-Pad2_ eSim_NPN
R3 Net-_D2-Pad2_ Net-_Q5-Pad3_ 2k
U1 Net-_Q17-Pad3_ Net-_J1-Pad2_ Net-_J2-Pad2_ Net-_D2-Pad2_ Net-_J5-Pad2_ Net-_J4-Pad2_ Net-_Q37-Pad3_ Net-_J3-Pad1_ PORT
R1 Net-_D2-Pad2_ Net-_Q1-Pad3_ 2k
Q3 Net-_Q1-Pad2_ unconnected-_Q3-Pad2_ Net-_D2-Pad2_ eSim_NPN
Q15 Net-_Q14-Pad1_ Net-_Q14-Pad1_ Net-_Q14-Pad2_ eSim_NPN
Q42 Net-_Q14-Pad1_ Net-_Q11-Pad1_ Net-_J3-Pad1_ eSim_PNP
Q17 Net-_Q14-Pad1_ Net-_Q17-Pad2_ Net-_Q17-Pad3_ eSim_NPN
Q14 Net-_Q14-Pad1_ Net-_Q14-Pad2_ Net-_C1-Pad2_ eSim_NPN
Q11 Net-_Q11-Pad1_ Net-_J3-Pad3_ Net-_Q11-Pad3_ eSim_NPN
Q12 Net-_Q11-Pad1_ Net-_Q11-Pad1_ Net-_J3-Pad1_ eSim_PNP
Q9 Net-_Q4-Pad2_ Net-_J3-Pad3_ Net-_Q11-Pad3_ eSim_NPN
Q7 Net-_J3-Pad1_ Net-_C1-Pad1_ Net-_Q13-Pad2_ eSim_NPN
C1 Net-_C1-Pad1_ Net-_C1-Pad2_ 10p
U2 Net-_D2-Pad2_ Net-_J3-Pad3_ zener
Q41 Net-_Q4-Pad2_ Net-_Q4-Pad3_ Net-_J3-Pad1_ eSim_PNP
J3 Net-_J3-Pad1_ Net-_J3-Pad1_ Net-_J3-Pad3_ jfet_p
R4 Net-_D2-Pad1_ Net-_Q11-Pad3_ 20k
Q10 Net-_D2-Pad2_ Net-_C1-Pad2_ Net-_C1-Pad1_ eSim_PNP
Q6 Net-_Q4-Pad3_ Net-_Q4-Pad3_ Net-_J3-Pad1_ eSim_PNP
Q5 Net-_C1-Pad1_ Net-_Q1-Pad2_ Net-_Q5-Pad3_ eSim_NPN
Q4 Net-_J1-Pad1_ Net-_Q4-Pad2_ Net-_Q4-Pad3_ eSim_PNP
R2 Net-_C1-Pad1_ Net-_J2-Pad3_ 1.8k
J2 Net-_J1-Pad1_ Net-_J2-Pad2_ Net-_J2-Pad3_ jfet_p
Q2 Net-_J3-Pad1_ Net-_J1-Pad3_ Net-_Q1-Pad2_ eSim_NPN
J1 Net-_J1-Pad1_ Net-_J1-Pad2_ Net-_J1-Pad3_ jfet_p
Q1 Net-_J1-Pad3_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
D3 Net-_D3-Pad1_ Net-_D2-Pad2_ eSim_Diode
D6 Net-_D6-Pad1_ Net-_D2-Pad2_ eSim_Diode
Q40 Net-_D2-Pad2_ Net-_C2-Pad2_ Net-_Q38-Pad2_ eSim_PNP
R18 Net-_Q38-Pad2_ Net-_Q37-Pad3_ 30
R17 Net-_Q37-Pad3_ Net-_Q37-Pad2_ 30
Q39 Net-_J3-Pad1_ Net-_Q34-Pad1_ Net-_Q37-Pad2_ eSim_NPN
Q24 Net-_J4-Pad1_ Net-_Q24-Pad2_ Net-_Q24-Pad3_ eSim_PNP
R8 Net-_Q17-Pad3_ Net-_Q17-Pad2_ 30
Q19 Net-_J3-Pad1_ Net-_Q14-Pad1_ Net-_Q17-Pad2_ eSim_NPN
J4 Net-_J4-Pad1_ Net-_J4-Pad2_ Net-_J4-Pad3_ jfet_p
Q26 Net-_Q24-Pad3_ Net-_Q24-Pad3_ Net-_J3-Pad1_ eSim_PNP
C2 Net-_C2-Pad1_ Net-_C2-Pad2_ 10p
J5 Net-_J4-Pad1_ Net-_J5-Pad2_ Net-_J5-Pad3_ jfet_p
J6 Net-_J3-Pad1_ Net-_J3-Pad1_ Net-_J6-Pad3_ jfet_p
Q43 Net-_Q24-Pad2_ Net-_Q24-Pad3_ Net-_J3-Pad1_ eSim_PNP
Q27 Net-_J3-Pad1_ Net-_C2-Pad1_ Net-_Q27-Pad3_ eSim_NPN
Q30 Net-_D2-Pad2_ Net-_C2-Pad2_ Net-_C2-Pad1_ eSim_PNP
R13 Net-_D5-Pad1_ Net-_Q29-Pad3_ 20k
Q28 Net-_Q27-Pad3_ Net-_D5-Pad1_ Net-_D2-Pad2_ eSim_NPN
U3 Net-_D2-Pad2_ Net-_J6-Pad3_ zener
Q31 Net-_Q31-Pad1_ Net-_J6-Pad3_ Net-_Q29-Pad3_ eSim_NPN
Q29 Net-_Q24-Pad2_ Net-_J6-Pad3_ Net-_Q29-Pad3_ eSim_NPN
Q32 Net-_Q31-Pad1_ Net-_Q31-Pad1_ Net-_J3-Pad1_ eSim_PNP
Q33 Net-_C2-Pad2_ Net-_Q27-Pad3_ Net-_Q33-Pad3_ eSim_NPN
D5 Net-_D5-Pad1_ Net-_D2-Pad2_ eSim_Diode
Q36 Net-_C2-Pad1_ Net-_D6-Pad1_ Net-_Q36-Pad3_ eSim_NPN
R16 Net-_D2-Pad2_ Net-_Q36-Pad3_ 160
R14 Net-_D2-Pad2_ Net-_Q33-Pad3_ 30
Q38 Net-_D6-Pad1_ Net-_Q38-Pad2_ Net-_Q37-Pad3_ eSim_PNP
R15 Net-_C2-Pad2_ Net-_Q34-Pad2_ 6k
Q34 Net-_Q34-Pad1_ Net-_Q34-Pad2_ Net-_C2-Pad2_ eSim_NPN
Q35 Net-_Q34-Pad1_ Net-_Q34-Pad1_ Net-_Q34-Pad2_ eSim_NPN
Q37 Net-_Q34-Pad1_ Net-_Q37-Pad2_ Net-_Q37-Pad3_ eSim_NPN
Q44 Net-_Q34-Pad1_ Net-_Q31-Pad1_ Net-_J3-Pad1_ eSim_PNP
Q21 Net-_J4-Pad3_ Net-_Q21-Pad2_ Net-_Q21-Pad3_ eSim_NPN
Q20 Net-_D2-Pad2_ Net-_C1-Pad2_ Net-_Q18-Pad2_ eSim_PNP
R10 Net-_D2-Pad2_ Net-_Q21-Pad3_ 2k
Q23 Net-_Q21-Pad2_ unconnected-_Q23-Pad2_ Net-_D2-Pad2_ eSim_NPN
R11 Net-_C2-Pad1_ Net-_J5-Pad3_ 1.8k
Q22 Net-_J3-Pad1_ Net-_J4-Pad3_ Net-_Q21-Pad2_ eSim_NPN
Q25 Net-_C2-Pad1_ Net-_Q21-Pad2_ Net-_Q25-Pad3_ eSim_NPN
R9 Net-_Q18-Pad2_ Net-_Q17-Pad3_ 30
R12 Net-_D2-Pad2_ Net-_Q25-Pad3_ 2k
.end
