* C:\FOSSEE\eSim\library\SubcircuitLibrary\CD4048BMS\CD4048BMS.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/03/25 11:26:02

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U2  Net-_U1-Pad14_ Net-_U17-Pad2_ d_inverter
U3  Net-_U1-Pad13_ Net-_U18-Pad2_ d_inverter
U4  Net-_U1-Pad12_ Net-_U19-Pad2_ d_inverter
U5  Net-_U1-Pad11_ Net-_U20-Pad2_ d_inverter
U6  Net-_U1-Pad15_ Net-_U6-Pad2_ d_inverter
U7  Net-_U1-Pad6_ Net-_U21-Pad2_ d_inverter
U8  Net-_U1-Pad5_ Net-_U22-Pad2_ d_inverter
U9  Net-_U1-Pad4_ Net-_U23-Pad2_ d_inverter
U10  Net-_U1-Pad3_ Net-_U10-Pad2_ d_inverter
U11  Net-_U1-Pad10_ Net-_U11-Pad2_ d_inverter
U12  Net-_U1-Pad7_ Net-_U12-Pad2_ d_inverter
U13  Net-_U1-Pad9_ Net-_U13-Pad2_ d_inverter
U14  Net-_U1-Pad2_ Net-_U14-Pad2_ d_inverter
U15  Net-_U11-Pad2_ Net-_U15-Pad2_ d_inverter
U16  Net-_U14-Pad2_ Net-_U16-Pad2_ d_inverter
U17  Net-_U15-Pad2_ Net-_U17-Pad2_ Net-_U17-Pad3_ d_xor
U18  Net-_U15-Pad2_ Net-_U18-Pad2_ Net-_U18-Pad3_ d_xor
U19  Net-_U15-Pad2_ Net-_U19-Pad2_ Net-_U19-Pad3_ d_xor
U20  Net-_U15-Pad2_ Net-_U20-Pad2_ Net-_U20-Pad3_ d_xor
U21  Net-_U15-Pad2_ Net-_U21-Pad2_ Net-_U21-Pad3_ d_xor
U22  Net-_U15-Pad2_ Net-_U22-Pad2_ Net-_U22-Pad3_ d_xor
U23  Net-_U15-Pad2_ Net-_U23-Pad2_ Net-_U23-Pad3_ d_xor
U24  Net-_U15-Pad2_ Net-_U10-Pad2_ Net-_U24-Pad3_ d_xor
X2  Net-_U17-Pad3_ Net-_U18-Pad3_ Net-_U19-Pad3_ Net-_U20-Pad3_ Net-_U25-Pad1_ 4_and
X3  Net-_U21-Pad3_ Net-_U22-Pad3_ Net-_U23-Pad3_ Net-_U24-Pad3_ Net-_U26-Pad1_ 4_and
U25  Net-_U25-Pad1_ Net-_U25-Pad2_ d_inverter
U26  Net-_U26-Pad1_ Net-_U26-Pad2_ d_inverter
U29  Net-_U12-Pad2_ Net-_U25-Pad2_ Net-_U29-Pad3_ d_xor
U28  Net-_U26-Pad2_ Net-_U12-Pad2_ Net-_U28-Pad3_ d_xor
X1  Net-_U29-Pad3_ Net-_U6-Pad2_ Net-_U28-Pad3_ Net-_U27-Pad1_ 3_and
U27  Net-_U27-Pad1_ Net-_U27-Pad2_ d_inverter
U30  Net-_U27-Pad2_ Net-_U13-Pad2_ Net-_U30-Pad3_ d_xor
U31  Net-_U16-Pad2_ Net-_U30-Pad3_ Net-_U31-Pad3_ d_and
U32  Net-_U30-Pad3_ Net-_U14-Pad2_ Net-_U32-Pad3_ d_or
U33  Net-_U31-Pad3_ Net-_U33-Pad2_ d_inverter
U34  Net-_U32-Pad3_ Net-_U34-Pad2_ d_inverter
M2  Net-_M1-Pad1_ Net-_M2-Pad2_ Net-_M2-Pad3_ Net-_M2-Pad3_ mosfet_n
U1  Net-_M1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_M2-Pad3_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ Net-_M1-Pad3_ PORT
U35  Net-_U33-Pad2_ Net-_U34-Pad2_ Net-_M1-Pad2_ Net-_M2-Pad2_ dac_bridge_2
M1  Net-_M1-Pad1_ Net-_M1-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_p

.end
