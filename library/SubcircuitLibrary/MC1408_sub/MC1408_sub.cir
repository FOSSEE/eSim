.title KiCad schematic
Q40 Net-_D11-Pad2_ Net-_Q40-Pad2_ Net-_Q16-Pad2_ eSim_PNP
Q36 Net-_D15-Pad1_ Net-_Q36-Pad2_ Net-_Q36-Pad3_ eSim_NPN
R19 Net-_R17-Pad1_ Net-_Q36-Pad3_ 800
R20 Net-_R20-Pad1_ Net-_R17-Pad1_ 400
Q34 Net-_Q16-Pad2_ Net-_Q31-Pad3_ Net-_Q18-Pad3_ eSim_NPN
Q31 Net-_D12-Pad1_ Net-_Q31-Pad2_ Net-_Q31-Pad3_ eSim_NPN
Q39 Net-_Q16-Pad2_ Net-_Q36-Pad3_ Net-_Q18-Pad3_ eSim_NPN
D18 Net-_D18-Pad1_ GND eSim_Diode
Q37 Net-_D15-Pad1_ Net-_Q16-Pad2_ Net-_Q36-Pad2_ eSim_NPN
D16 Net-_D13-Pad1_ Net-_D13-Pad1_ eSim_Diode
R18 Net-_D13-Pad1_ Net-_Q11-Pad1_ 5k
Q44 Net-_D18-Pad1_ Net-_Q44-Pad2_ Net-_Q44-Pad3_ eSim_NPN
R22 Net-_D13-Pad1_ Net-_Q11-Pad1_ 5k
Q38 Net-_Q16-Pad2_ Net-_Q16-Pad2_ Net-_Q11-Pad1_ eSim_PNP
U1 Net-_D24-Pad1_ GND Net-_D11-Pad2_ Net-_D14-Pad1_ Net-_Q1-Pad2_ Net-_Q12-Pad2_ Net-_Q19-Pad2_ Net-_Q30-Pad2_ Net-_Q35-Pad2_ Net-_Q43-Pad2_ Net-_Q50-Pad2_ Net-_Q56-Pad2_ Net-_Q11-Pad1_ Net-_Q14-Pad2_ Net-_Q29-Pad2_ Net-_Q11-Pad2_ PORT
D19 Net-_D13-Pad1_ Net-_D13-Pad1_ eSim_Diode
Q43 Net-_D18-Pad1_ Net-_Q43-Pad2_ Net-_D13-Pad1_ eSim_PNP
Q32 Net-_D12-Pad1_ Net-_Q16-Pad2_ Net-_Q31-Pad2_ eSim_NPN
D14 Net-_D14-Pad1_ Net-_D12-Pad1_ eSim_Diode
R15 Net-_D13-Pad1_ Net-_Q11-Pad1_ 5k
Q51 Net-_D23-Pad1_ Net-_Q51-Pad2_ Net-_Q51-Pad3_ eSim_NPN
R28 Net-_R25-Pad1_ Net-_Q51-Pad3_ 800
Q50 Net-_D23-Pad1_ Net-_Q50-Pad2_ Net-_D13-Pad1_ eSim_PNP
D29 Net-_D14-Pad1_ Net-_D23-Pad1_ eSim_Diode
Q52 GND Net-_Q16-Pad2_ Net-_Q51-Pad2_ eSim_NPN
Q46 Net-_D18-Pad1_ Net-_Q16-Pad2_ Net-_Q44-Pad2_ eSim_NPN
D20 Net-_D14-Pad1_ Net-_D18-Pad1_ eSim_Diode
R25 Net-_R25-Pad1_ Net-_R20-Pad1_ 400
R23 Net-_R20-Pad1_ Net-_Q44-Pad3_ 800
Q48 Net-_Q16-Pad2_ Net-_Q44-Pad3_ Net-_Q18-Pad3_ eSim_NPN
Q30 Net-_D12-Pad1_ Net-_Q30-Pad2_ Net-_D13-Pad1_ eSim_PNP
D15 Net-_D15-Pad1_ GND eSim_Diode
Q35 Net-_D15-Pad1_ Net-_Q35-Pad2_ Net-_D13-Pad1_ eSim_PNP
D17 Net-_D14-Pad1_ Net-_D15-Pad1_ eSim_Diode
Q33 Net-_Q16-Pad2_ Net-_Q16-Pad2_ Net-_Q11-Pad1_ eSim_PNP
Q47 Net-_Q16-Pad2_ Net-_Q16-Pad2_ Net-_Q11-Pad1_ eSim_PNP
R27 Net-_D13-Pad1_ Net-_Q11-Pad1_ 5k
D28 Net-_D13-Pad1_ Net-_D13-Pad1_ eSim_Diode
D23 Net-_D23-Pad1_ GND eSim_Diode
Q57 GND Net-_Q55-Pad2_ Net-_Q55-Pad3_ eSim_NPN
R32 Net-_R25-Pad1_ Net-_Q55-Pad3_ 800
Q58 GND Net-_Q16-Pad2_ Net-_Q55-Pad2_ eSim_NPN
Q55 GND Net-_Q55-Pad2_ Net-_Q55-Pad3_ eSim_NPN
Q53 Net-_Q16-Pad2_ Net-_Q16-Pad2_ Net-_Q11-Pad1_ eSim_PNP
D30 GND GND eSim_Diode
D31 Net-_D13-Pad1_ Net-_D13-Pad1_ eSim_Diode
Q56 GND Net-_Q56-Pad2_ Net-_D13-Pad1_ eSim_PNP
D32 Net-_D14-Pad1_ GND eSim_Diode
R31 Net-_D13-Pad1_ Net-_Q11-Pad1_ 5k
R34 GND Net-_D33-Pad2_ 3k
Q61 Net-_Q61-Pad1_ Net-_D33-Pad2_ GND eSim_NPN
D33 Net-_D13-Pad1_ Net-_D33-Pad2_ eSim_Diode
R33 Net-_Q61-Pad1_ Net-_Q11-Pad1_ 3k
Q59 Net-_Q16-Pad2_ Net-_Q16-Pad2_ Net-_Q11-Pad1_ eSim_PNP
Q60 Net-_Q16-Pad2_ Net-_Q55-Pad3_ Net-_Q18-Pad3_ eSim_NPN
D3 Net-_D14-Pad1_ Net-_D1-Pad1_ eSim_Diode
D1 Net-_D1-Pad1_ GND eSim_Diode
Q2 Net-_D1-Pad1_ Net-_Q2-Pad2_ Net-_Q2-Pad3_ eSim_NPN
R2 Net-_Q3-Pad1_ Net-_Q2-Pad3_ 800
R4 Net-_R4-Pad1_ Net-_Q3-Pad1_ 400
Q24 Net-_Q16-Pad2_ Net-_Q16-Pad2_ Net-_Q11-Pad1_ eSim_PNP
Q1 Net-_D1-Pad1_ Net-_Q1-Pad2_ Net-_D2-Pad1_ eSim_PNP
Q6 Net-_Q16-Pad2_ Net-_Q16-Pad2_ Net-_Q11-Pad1_ eSim_PNP
R6 Net-_D5-Pad1_ Net-_Q11-Pad1_ 1.7k
R1 Net-_D2-Pad1_ Net-_Q11-Pad1_ 1.7k
D5 Net-_D5-Pad1_ Net-_D13-Pad1_ eSim_Diode
R9 Net-_D13-Pad1_ Net-_Q11-Pad1_ 3.5k
Q17 Net-_Q16-Pad2_ Net-_Q16-Pad2_ Net-_Q11-Pad1_ eSim_PNP
Q27 Net-_Q11-Pad2_ Net-_D10-Pad1_ Net-_Q27-Pad3_ eSim_NPN
R11 Net-_Q20-Pad3_ Net-_D10-Pad1_ 6.2k
Q20 Net-_Q11-Pad1_ Net-_Q14-Pad1_ Net-_Q20-Pad3_ eSim_NPN
D10 Net-_D10-Pad1_ Net-_D10-Pad2_ eSim_Diode
Q15 Net-_Q14-Pad1_ Net-_D10-Pad2_ Net-_D11-Pad2_ eSim_NPN
D11 Net-_D10-Pad2_ Net-_D11-Pad2_ eSim_Diode
Q28 Net-_Q27-Pad3_ Net-_D10-Pad2_ Net-_D11-Pad2_ eSim_NPN
Q19 Net-_D7-Pad1_ Net-_Q19-Pad2_ Net-_D13-Pad1_ eSim_PNP
D9 Net-_D14-Pad1_ Net-_D7-Pad1_ eSim_Diode
Q12 Net-_D4-Pad1_ Net-_Q12-Pad2_ Net-_D5-Pad1_ eSim_PNP
D6 Net-_D14-Pad1_ Net-_D4-Pad1_ eSim_Diode
Q21 Net-_D7-Pad1_ Net-_Q21-Pad2_ Net-_Q21-Pad3_ eSim_NPN
D7 Net-_D7-Pad1_ GND eSim_Diode
D4 Net-_D4-Pad1_ GND eSim_Diode
Q7 Net-_Q16-Pad2_ Net-_Q2-Pad3_ Net-_Q18-Pad3_ eSim_NPN
Q4 Net-_D1-Pad1_ Net-_Q16-Pad2_ Net-_Q2-Pad2_ eSim_NPN
D2 Net-_D2-Pad1_ Net-_D13-Pad1_ eSim_Diode
Q13 Net-_D4-Pad1_ Net-_Q13-Pad2_ Net-_Q13-Pad3_ eSim_NPN
Q16 Net-_D4-Pad1_ Net-_Q16-Pad2_ Net-_Q13-Pad2_ eSim_NPN
Q18 Net-_Q16-Pad2_ Net-_Q13-Pad3_ Net-_Q18-Pad3_ eSim_NPN
Q25 Net-_Q16-Pad2_ Net-_Q21-Pad3_ Net-_Q18-Pad3_ eSim_NPN
D12 Net-_D12-Pad1_ GND eSim_Diode
D13 Net-_D13-Pad1_ Net-_D13-Pad1_ eSim_Diode
D8 Net-_D13-Pad1_ Net-_D13-Pad1_ eSim_Diode
Q23 Net-_D7-Pad1_ Net-_Q16-Pad2_ Net-_Q21-Pad2_ eSim_NPN
R10 Net-_R10-Pad1_ Net-_Q21-Pad3_ 800
R16 Net-_R13-Pad1_ Net-_Q31-Pad3_ 800
R17 Net-_R17-Pad1_ Net-_R13-Pad1_ 400
Q29 Net-_Q11-Pad2_ Net-_Q29-Pad2_ Net-_Q29-Pad3_ eSim_PNP
R14 Net-_Q26-Pad1_ Net-_Q29-Pad3_ 4k
R12 Net-_Q14-Pad3_ Net-_Q26-Pad1_ 4k
Q26 Net-_Q26-Pad1_ Net-_Q16-Pad2_ Net-_Q11-Pad1_ eSim_PNP
R8 Net-_R10-Pad1_ Net-_R4-Pad1_ 400
Q14 Net-_Q14-Pad1_ Net-_Q14-Pad2_ Net-_Q14-Pad3_ eSim_PNP
Q22 Net-_Q11-Pad1_ Net-_Q14-Pad1_ Net-_Q11-Pad2_ eSim_NPN
R13 Net-_R13-Pad1_ Net-_R10-Pad1_ 400
Q10 Net-_Q10-Pad1_ Net-_D10-Pad2_ Net-_D11-Pad2_ eSim_NPN
Q9 Net-_Q3-Pad2_ Net-_D10-Pad2_ Net-_D11-Pad2_ eSim_NPN
R7 Net-_R4-Pad1_ Net-_Q13-Pad3_ 800
R5 Net-_D11-Pad2_ Net-_Q5-Pad3_ 35
R3 Net-_D11-Pad2_ Net-_Q3-Pad3_ 35
Q3 Net-_Q3-Pad1_ Net-_Q3-Pad2_ Net-_Q3-Pad3_ eSim_NPN
Q5 Net-_Q14-Pad2_ Net-_Q3-Pad2_ Net-_Q5-Pad3_ eSim_NPN
Q11 Net-_Q11-Pad1_ Net-_Q11-Pad2_ Net-_Q10-Pad1_ eSim_NPN
Q8 Net-_Q11-Pad1_ Net-_Q10-Pad1_ Net-_Q3-Pad2_ eSim_NPN
Q54 Net-_Q16-Pad2_ Net-_Q51-Pad3_ Net-_Q18-Pad3_ eSim_NPN
R30 GND Net-_D24-Pad1_ 3k
R24 Net-_D21-Pad1_ Net-_Q45-Pad3_ 10k
Q41 Net-_Q40-Pad2_ Net-_Q16-Pad2_ Net-_Q11-Pad1_ eSim_PNP
Q45 Net-_Q11-Pad1_ Net-_Q45-Pad2_ Net-_Q45-Pad3_ eSim_NPN
R26 Net-_Q45-Pad2_ Net-_Q11-Pad1_ 25k
D24 Net-_D24-Pad1_ Net-_D24-Pad2_ eSim_Diode
D22 Net-_D21-Pad2_ Net-_D11-Pad2_ eSim_Diode
U2 Net-_D11-Pad2_ Net-_Q45-Pad2_ zener
D21 Net-_D21-Pad1_ Net-_D21-Pad2_ eSim_Diode
R21 Net-_D11-Pad2_ Net-_Q42-Pad3_ 8k
Q42 Net-_Q40-Pad2_ Net-_D21-Pad2_ Net-_Q42-Pad3_ eSim_NPN
R29 Net-_D11-Pad2_ Net-_D27-Pad1_ 3k
D25 Net-_D24-Pad2_ Net-_D25-Pad2_ eSim_Diode
U3 Net-_D26-Pad2_ Net-_Q18-Pad3_ zener
Q49 Net-_Q18-Pad3_ Net-_D21-Pad1_ Net-_D27-Pad1_ eSim_NPN
D26 Net-_D25-Pad2_ Net-_D26-Pad2_ eSim_Diode
D27 Net-_D27-Pad1_ Net-_D11-Pad2_ eSim_Diode
.end
