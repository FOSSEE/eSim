.title KiCad schematic
U1 Net-_U44-Pad2_ Net-_U12-Pad1_ Net-_U8-Pad1_ Net-_U43-Pad2_ Net-_U3-Pad1_ Net-_U4-Pad1_ Net-_U2-Pad1_ Net-_U72-Pad2_ Net-_U67-Pad2_ Net-_U26-Pad1_ Net-_U23-Pad1_ Net-_U57-Pad2_ Net-_U16-Pad1_ Net-_U20-Pad1_ PORT
U20 Net-_U20-Pad1_ Net-_U20-Pad2_ d_buffer
U16 Net-_U16-Pad1_ Net-_U16-Pad2_ d_buffer
U12 Net-_U12-Pad1_ Net-_U12-Pad2_ d_buffer
U32 Net-_U16-Pad2_ Net-_U20-Pad2_ Net-_U32-Pad3_ d_and
U30 Net-_U30-Pad1_ Net-_U12-Pad2_ Net-_U30-Pad3_ d_and
U31 Net-_U30-Pad1_ Net-_U12-Pad2_ Net-_U31-Pad3_ d_xor
U26 Net-_U26-Pad1_ Net-_U26-Pad2_ d_buffer
U29 Net-_U28-Pad1_ Net-_U28-Pad2_ Net-_U29-Pad3_ d_xor
U23 Net-_U23-Pad1_ Net-_U23-Pad2_ d_buffer
U28 Net-_U28-Pad1_ Net-_U28-Pad2_ Net-_U28-Pad3_ d_and
U34 Net-_U23-Pad2_ Net-_U26-Pad2_ Net-_U34-Pad3_ d_and
U35 Net-_U23-Pad2_ Net-_U26-Pad2_ Net-_U35-Pad3_ d_xor
U33 Net-_U16-Pad2_ Net-_U20-Pad2_ Net-_U33-Pad3_ d_xor
U43 Net-_U39-Pad3_ Net-_U43-Pad2_ d_buffer
U44 Net-_U41-Pad3_ Net-_U44-Pad2_ d_buffer
U41 Net-_U31-Pad3_ Net-_U38-Pad3_ Net-_U41-Pad3_ d_xor
U45 Net-_U40-Pad3_ Net-_U2-Pad2_ Net-_U45-Pad3_ d_and
U39 Net-_U29-Pad3_ Net-_U2-Pad2_ Net-_U39-Pad3_ d_xor
U38 Net-_U28-Pad3_ Net-_U36-Pad3_ Net-_U38-Pad3_ d_or
U36 Net-_U29-Pad3_ Net-_U2-Pad2_ Net-_U36-Pad3_ d_and
U42 Net-_U30-Pad3_ Net-_U37-Pad3_ Net-_U42-Pad3_ d_or
U40 Net-_U29-Pad3_ Net-_U31-Pad3_ Net-_U40-Pad3_ d_and
U37 Net-_U28-Pad3_ Net-_U31-Pad3_ Net-_U37-Pad3_ d_and
U56 Net-_U54-Pad3_ Net-_U34-Pad3_ Net-_U56-Pad3_ d_or
U54 Net-_U32-Pad3_ Net-_U35-Pad3_ Net-_U54-Pad3_ d_and
U48 Net-_U45-Pad3_ Net-_U33-Pad3_ Net-_U48-Pad3_ d_and
U67 Net-_U65-Pad3_ Net-_U67-Pad2_ d_buffer
U68 Net-_U66-Pad3_ Net-_U35-Pad3_ Net-_U68-Pad3_ d_or
U60 Net-_U48-Pad3_ Net-_U35-Pad3_ Net-_U60-Pad3_ d_and
U52 Net-_U30-Pad3_ Net-_U33-Pad3_ Net-_U52-Pad3_ d_and
U53 Net-_U32-Pad3_ Net-_U48-Pad3_ Net-_U53-Pad3_ d_or
U50 Net-_U45-Pad3_ Net-_U42-Pad3_ Net-_U50-Pad3_ d_or
U55 Net-_U50-Pad3_ Net-_U33-Pad3_ Net-_U55-Pad3_ d_xor
U62 Net-_U58-Pad3_ Net-_U59-Pad3_ Net-_U62-Pad3_ d_or
U63 Net-_U59-Pad3_ Net-_U35-Pad3_ Net-_U63-Pad3_ d_and
U65 Net-_U62-Pad3_ Net-_U35-Pad3_ Net-_U65-Pad3_ d_xor
U72 Net-_U70-Pad3_ Net-_U72-Pad2_ d_buffer
U70 Net-_U68-Pad3_ Net-_U56-Pad3_ Net-_U70-Pad3_ d_or
U66 Net-_U63-Pad3_ Net-_U60-Pad3_ Net-_U66-Pad3_ d_or
U59 Net-_U37-Pad3_ Net-_U33-Pad3_ Net-_U59-Pad3_ d_and
U57 Net-_U55-Pad3_ Net-_U57-Pad2_ d_buffer
U58 Net-_U53-Pad3_ Net-_U52-Pad3_ Net-_U58-Pad3_ d_or
U2 Net-_U2-Pad1_ Net-_U2-Pad2_ d_buffer
U3 Net-_U3-Pad1_ Net-_U28-Pad1_ d_buffer
U4 Net-_U4-Pad1_ Net-_U28-Pad2_ d_buffer
U8 Net-_U8-Pad1_ Net-_U30-Pad1_ d_buffer
.end
