* C:\FOSSEE\eSim\library\SubcircuitLibrary\LM160\LM160.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 07/03/24 23:07:48

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
R4  Net-_Q6-Pad1_ Net-_Q13-Pad3_ 1k
R8  Net-_Q6-Pad1_ Net-_Q13-Pad2_ 4k
R9  Net-_Q6-Pad1_ Net-_Q14-Pad3_ 1.4k
R13  Net-_Q6-Pad1_ Net-_Q18-Pad1_ 85
Q13  Net-_Q13-Pad1_ Net-_Q13-Pad2_ Net-_Q13-Pad3_ eSim_NPN
Q17  Net-_Q14-Pad3_ Net-_Q13-Pad1_ Net-_D1-Pad1_ eSim_NPN
Q14  Net-_Q13-Pad1_ Net-_Q13-Pad2_ Net-_Q14-Pad3_ eSim_NPN
Q15  Net-_Q14-Pad3_ Net-_Q13-Pad1_ Net-_Q15-Pad3_ eSim_NPN
D1  Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
Q18  Net-_Q18-Pad1_ Net-_Q14-Pad3_ Net-_D1-Pad1_ eSim_NPN
R10  Net-_Q15-Pad3_ Net-_Q21-Pad2_ 205
R11  Net-_Q21-Pad2_ GND 800
Q21  Net-_D1-Pad2_ Net-_Q21-Pad2_ GND eSim_NPN
Q4  Net-_Q25-Pad1_ Net-_Q3-Pad1_ Net-_Q4-Pad3_ eSim_NPN
U2  Net-_Q12-Pad2_ Net-_Q4-Pad3_ zener
Q6  Net-_Q6-Pad1_ Net-_Q1-Pad1_ Net-_Q6-Pad3_ eSim_NPN
U3  Net-_Q7-Pad1_ Net-_Q6-Pad3_ zener
Q8  Net-_Q8-Pad1_ Net-_Q7-Pad1_ Net-_Q10-Pad1_ eSim_NPN
R5  Net-_Q13-Pad3_ Net-_Q8-Pad1_ 1.3k
Q9  Net-_Q13-Pad3_ Net-_Q8-Pad1_ GND eSim_NPN
Q11  Net-_Q11-Pad1_ Net-_Q11-Pad2_ GND eSim_NPN
Q12  Net-_Q11-Pad2_ Net-_Q12-Pad2_ Net-_Q10-Pad1_ eSim_NPN
R7  Net-_Q11-Pad1_ Net-_Q11-Pad2_ 1.3k
R6  Net-_Q25-Pad1_ Net-_Q11-Pad1_ 1k
R3  Net-_Q25-Pad1_ Net-_Q3-Pad1_ 1450
Q3  Net-_Q3-Pad1_ Net-_Q3-Pad2_ Net-_Q1-Pad3_ eSim_NPN
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
R1  Net-_Q25-Pad1_ Net-_Q1-Pad1_ 1450
Q2  Net-_Q1-Pad3_ Net-_Q2-Pad2_ Net-_Q2-Pad3_ eSim_NPN
R2  Net-_Q2-Pad3_ Net-_Q10-Pad3_ 400
Q5  Net-_Q12-Pad2_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
Q7  Net-_Q7-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
R12  Net-_Q25-Pad1_ Net-_Q16-Pad2_ 4k
R14  Net-_Q25-Pad1_ Net-_Q19-Pad3_ 1.4k
R17  Net-_Q25-Pad1_ Net-_Q23-Pad1_ 85
Q16  Net-_Q16-Pad1_ Net-_Q16-Pad2_ Net-_Q11-Pad1_ eSim_NPN
Q22  Net-_Q19-Pad3_ Net-_Q16-Pad1_ Net-_D2-Pad1_ eSim_NPN
Q19  Net-_Q16-Pad1_ Net-_Q16-Pad2_ Net-_Q19-Pad3_ eSim_NPN
Q20  Net-_Q19-Pad3_ Net-_Q16-Pad1_ Net-_Q20-Pad3_ eSim_NPN
D2  Net-_D2-Pad1_ Net-_D2-Pad2_ eSim_Diode
Q23  Net-_Q23-Pad1_ Net-_Q19-Pad3_ Net-_D2-Pad1_ eSim_NPN
R15  Net-_Q20-Pad3_ Net-_Q24-Pad2_ 205
R16  Net-_Q24-Pad2_ GND 800
Q24  Net-_D2-Pad2_ Net-_Q24-Pad2_ GND eSim_NPN
Q25  Net-_Q25-Pad1_ Net-_Q25-Pad2_ Net-_Q25-Pad3_ eSim_NPN
R18  Net-_Q25-Pad3_ Net-_Q2-Pad2_ 3.2k
R19  Net-_Q2-Pad2_ Net-_Q10-Pad2_ 387
R20  Net-_Q25-Pad1_ Net-_Q25-Pad2_ 5k
U4  Net-_Q10-Pad3_ Net-_Q25-Pad2_ zener
Q26  Net-_Q10-Pad2_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
U1  Net-_Q25-Pad1_ Net-_Q3-Pad2_ Net-_Q1-Pad2_ Net-_Q10-Pad3_ Net-_D1-Pad2_ GND Net-_D2-Pad2_ PORT

.end
