.title KiCad schematic
U1 Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ unconnected-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ Net-_U1-Pad16_ PORT
U7 Net-_U2-Pad2_ Net-_U14-Pad4_ Net-_U11-Pad1_ d_nor
U11 Net-_U11-Pad1_ Net-_U11-Pad2_ d_inverter
U9 Net-_U3-Pad2_ Net-_U14-Pad4_ d_inverter
U2 Net-_U1-Pad1_ Net-_U2-Pad2_ d_inverter
U3 Net-_U1-Pad2_ Net-_U3-Pad2_ d_inverter
U6 Net-_U1-Pad4_ Net-_U20-Pad2_ d_inverter
U15 Net-_U1-Pad16_ Net-_U13-Pad2_ unconnected-_U15-Pad3_ Net-_U10-Pad2_ Net-_U15-Pad5_ unconnected-_U15-Pad6_ d_tff
U21 Net-_U21-Pad1_ Net-_U21-Pad2_ Net-_U21-Pad3_ d_or
U18 Net-_U15-Pad5_ Net-_U18-Pad2_ d_inverter
U24 Net-_U21-Pad3_ Net-_U10-Pad2_ Net-_U24-Pad3_ d_nor
U25 Net-_U24-Pad3_ Net-_U25-Pad2_ d_inverter
U27 Net-_U1-Pad16_ Net-_U25-Pad2_ unconnected-_U27-Pad3_ Net-_U10-Pad2_ Net-_U27-Pad5_ unconnected-_U27-Pad6_ d_tff
U33 Net-_U27-Pad5_ Net-_U33-Pad2_ d_inverter
U23 Net-_U22-Pad3_ Net-_U23-Pad2_ d_inverter
U22 Net-_U20-Pad3_ Net-_U14-Pad4_ Net-_U22-Pad3_ d_nor
U16 Net-_U14-Pad5_ Net-_U16-Pad2_ d_inverter
U14 Net-_U1-Pad16_ Net-_U11-Pad2_ unconnected-_U14-Pad3_ Net-_U14-Pad4_ Net-_U14-Pad5_ unconnected-_U14-Pad6_ d_tff
U20 Net-_U20-Pad1_ Net-_U20-Pad2_ Net-_U20-Pad3_ d_or
U26 Net-_U1-Pad16_ Net-_U23-Pad2_ unconnected-_U26-Pad3_ Net-_U14-Pad4_ Net-_U26-Pad5_ unconnected-_U26-Pad6_ d_tff
U8 Net-_U1-Pad12_ Net-_U21-Pad2_ d_inverter
U13 Net-_U10-Pad3_ Net-_U13-Pad2_ d_inverter
U10 Net-_U10-Pad1_ Net-_U10-Pad2_ Net-_U10-Pad3_ d_nor
U4 Net-_U1-Pad15_ Net-_U10-Pad1_ d_inverter
U5 Net-_U1-Pad14_ Net-_U12-Pad1_ d_inverter
U12 Net-_U12-Pad1_ Net-_U10-Pad2_ d_inverter
U30 Net-_U26-Pad5_ Net-_U30-Pad2_ d_inverter
U28 Net-_U26-Pad5_ Net-_U28-Pad2_ d_inverter
U29 Net-_U28-Pad2_ Net-_U1-Pad5_ d_inverter
U17 Net-_U16-Pad2_ Net-_U1-Pad3_ d_inverter
U44 Net-_U20-Pad2_ Net-_U42-Pad3_ Net-_U44-Pad3_ d_or
U50 Net-_U1-Pad16_ Net-_U47-Pad2_ unconnected-_U50-Pad3_ Net-_U14-Pad4_ Net-_U20-Pad1_ unconnected-_U50-Pad6_ d_tff
U46 Net-_U44-Pad3_ Net-_U14-Pad4_ Net-_U46-Pad3_ d_nor
U53 Net-_U52-Pad2_ Net-_U1-Pad7_ d_inverter
U52 Net-_U20-Pad1_ Net-_U52-Pad2_ d_inverter
U37 Net-_U36-Pad2_ Net-_U1-Pad6_ d_inverter
U36 Net-_U34-Pad5_ Net-_U36-Pad2_ d_inverter
U47 Net-_U46-Pad3_ Net-_U47-Pad2_ d_inverter
U43 Net-_U21-Pad1_ Net-_U41-Pad3_ Net-_U43-Pad3_ d_nor
U48 Net-_U45-Pad3_ Net-_U10-Pad2_ Net-_U48-Pad3_ d_nor
U51 Net-_U1-Pad16_ Net-_U49-Pad2_ unconnected-_U51-Pad3_ Net-_U10-Pad2_ Net-_U21-Pad1_ unconnected-_U51-Pad6_ d_tff
U49 Net-_U48-Pad3_ Net-_U49-Pad2_ d_inverter
U54 Net-_U21-Pad1_ Net-_U54-Pad2_ d_inverter
U55 Net-_U54-Pad2_ Net-_U1-Pad9_ d_inverter
U45 Net-_U21-Pad2_ Net-_U43-Pad3_ Net-_U45-Pad3_ d_or
U42 Net-_U20-Pad1_ Net-_U40-Pad3_ Net-_U42-Pad3_ d_nor
U34 Net-_U1-Pad16_ Net-_U30-Pad2_ unconnected-_U34-Pad3_ Net-_U14-Pad4_ Net-_U34-Pad5_ unconnected-_U34-Pad6_ d_tff
U40 Net-_U26-Pad5_ Net-_U34-Pad5_ Net-_U40-Pad3_ d_and
U35 Net-_U1-Pad16_ Net-_U33-Pad2_ unconnected-_U35-Pad3_ Net-_U10-Pad2_ Net-_U35-Pad5_ unconnected-_U35-Pad6_ d_tff
U41 Net-_U27-Pad5_ Net-_U35-Pad5_ Net-_U41-Pad3_ d_and
U39 Net-_U38-Pad2_ Net-_U1-Pad10_ d_inverter
U38 Net-_U35-Pad5_ Net-_U38-Pad2_ d_inverter
U31 Net-_U27-Pad5_ Net-_U31-Pad2_ d_inverter
U32 Net-_U31-Pad2_ Net-_U1-Pad11_ d_inverter
U19 Net-_U18-Pad2_ Net-_U1-Pad13_ d_inverter
.end
