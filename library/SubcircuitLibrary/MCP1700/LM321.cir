* C:\FOSSEE\eSim\library\SubcircuitLibrary\LM321\LM321.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 08/04/22 16:17:25

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U1  Net-_Q12-Pad2_ Net-_Q3-Pad2_ Net-_J1-Pad1_ Net-_Q24-Pad3_ Net-_J1-Pad2_ PORT
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_J1-Pad1_ eSim_PNP
Q14  Net-_Q14-Pad1_ Net-_Q1-Pad2_ Net-_J1-Pad1_ eSim_PNP
Q19  Net-_Q1-Pad2_ Net-_Q1-Pad2_ Net-_J1-Pad1_ eSim_PNP
Q4  Net-_Q3-Pad3_ Net-_Q3-Pad3_ Net-_Q11-Pad3_ eSim_PNP
Q11  Net-_Q11-Pad1_ Net-_Q11-Pad1_ Net-_Q11-Pad3_ eSim_PNP
Q3  Net-_J1-Pad2_ Net-_Q3-Pad2_ Net-_Q3-Pad3_ eSim_PNP
Q12  Net-_J1-Pad2_ Net-_Q12-Pad2_ Net-_Q11-Pad1_ eSim_PNP
Q2  Net-_J1-Pad2_ Net-_Q2-Pad2_ Net-_Q1-Pad1_ eSim_PNP
Q9  Net-_C1-Pad2_ Net-_Q2-Pad2_ Net-_J1-Pad2_ eSim_NPN
Q5  Net-_Q2-Pad2_ Net-_Q2-Pad2_ Net-_J1-Pad2_ eSim_NPN
Q13  Net-_J1-Pad2_ Net-_C1-Pad2_ Net-_Q10-Pad1_ eSim_PNP
Q15  Net-_Q14-Pad1_ Net-_Q10-Pad1_ Net-_Q15-Pad3_ eSim_NPN
Q17  Net-_Q15-Pad3_ Net-_Q16-Pad1_ Net-_J1-Pad2_ eSim_NPN
Q18  Net-_J1-Pad2_ Net-_Q16-Pad1_ Net-_Q14-Pad1_ eSim_PNP
Q20  Net-_Q16-Pad1_ Net-_Q16-Pad1_ Net-_J1-Pad2_ eSim_NPN
Q21  Net-_C1-Pad1_ Net-_Q15-Pad3_ Net-_J1-Pad2_ eSim_NPN
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 5p
Q24  Net-_C1-Pad1_ Net-_Q24-Pad2_ Net-_Q24-Pad3_ eSim_NPN
R1  Net-_Q23-Pad3_ Net-_Q24-Pad2_ 40k
Q23  Net-_J1-Pad1_ Net-_C1-Pad1_ Net-_Q23-Pad3_ eSim_NPN
Q25  Net-_J1-Pad1_ Net-_Q23-Pad3_ Net-_Q24-Pad2_ eSim_NPN
R2  Net-_Q24-Pad2_ Net-_Q24-Pad3_ 25
Q26  Net-_J1-Pad2_ Net-_C1-Pad1_ Net-_Q24-Pad3_ eSim_PNP
Q27  Net-_Q24-Pad3_ Net-_Q16-Pad1_ Net-_J1-Pad2_ eSim_NPN
Q28  Net-_Q1-Pad2_ Net-_Q28-Pad2_ Net-_Q28-Pad3_ eSim_NPN
R3  Net-_Q28-Pad3_ Net-_J1-Pad2_ 2k
J1  Net-_J1-Pad1_ Net-_J1-Pad2_ Net-_J1-Pad3_ jfet_n
Q31  Net-_J1-Pad1_ Net-_J1-Pad3_ Net-_Q30-Pad2_ eSim_NPN
Q29  Net-_J1-Pad3_ Net-_J1-Pad3_ Net-_Q28-Pad2_ eSim_NPN
Q30  Net-_Q28-Pad2_ Net-_Q30-Pad2_ Net-_J1-Pad2_ eSim_NPN
R4  Net-_Q30-Pad2_ Net-_J1-Pad2_ 2.4k
Q7  Net-_Q11-Pad3_ Net-_Q1-Pad2_ Net-_J1-Pad1_ eSim_PNP
Q10  Net-_Q10-Pad1_ Net-_Q1-Pad2_ Net-_J1-Pad1_ eSim_PNP
Q16  Net-_Q16-Pad1_ Net-_Q1-Pad2_ Net-_J1-Pad1_ eSim_PNP
Q6  Net-_Q2-Pad2_ Net-_Q3-Pad3_ Net-_Q11-Pad3_ eSim_PNP
Q8  Net-_C1-Pad2_ Net-_Q11-Pad1_ Net-_Q11-Pad3_ eSim_PNP
Q22  Net-_C1-Pad1_ Net-_Q1-Pad2_ Net-_J1-Pad1_ eSim_PNP

.end
