.title KiCad schematic
R2 Net-_Q1-Pad3_ Net-_J1-Pad1_ 310
Q3 Net-_Q1-Pad2_ Net-_Q3-Pad2_ Net-_Q1-Pad1_ eSim_NPN
Q1 Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_PNP
J1 Net-_J1-Pad1_ Net-_C1-Pad2_ Net-_J1-Pad3_ jfet_n
R1 Net-_J1-Pad3_ Net-_Q3-Pad2_ 200k
R5 Net-_Q2-Pad2_ Net-_Q3-Pad2_ 4k
Q5 Net-_Q5-Pad1_ Net-_Q2-Pad2_ Net-_C1-Pad2_ eSim_NPN
Q6 Net-_C1-Pad2_ Net-_Q5-Pad1_ Net-_Q10-Pad3_ eSim_PNP
R6 Net-_Q5-Pad1_ Net-_Q2-Pad2_ 130
Q2 Net-_Q1-Pad1_ Net-_Q2-Pad2_ Net-_Q2-Pad3_ eSim_NPN
R3 Net-_C1-Pad2_ Net-_Q2-Pad3_ 180
U1 Net-_C1-Pad2_ Net-_J1-Pad3_ zener
Q13 Net-_J1-Pad1_ Net-_Q13-Pad2_ Net-_Q12-Pad2_ eSim_NPN
Q4 Net-_Q3-Pad2_ Net-_Q1-Pad2_ Net-_Q4-Pad3_ eSim_PNP
R4 Net-_Q4-Pad3_ Net-_J1-Pad1_ 310
R7 Net-_Q7-Pad3_ Net-_J1-Pad1_ 190
R10 Net-_Q9-Pad3_ Net-_J1-Pad1_ 82
R14 Net-_Q14-Pad3_ Net-_J1-Pad1_ 5.6k
Q7 Net-_Q10-Pad3_ Net-_Q1-Pad2_ Net-_Q7-Pad3_ eSim_PNP
Q9 Net-_Q11-Pad1_ Net-_Q1-Pad2_ Net-_Q9-Pad3_ eSim_PNP
R9 Net-_C1-Pad2_ Net-_Q8-Pad3_ 4.1k
R11 Net-_C1-Pad2_ Net-_Q10-Pad1_ 5.8k
R12 Net-_C1-Pad2_ Net-_Q11-Pad3_ 72
Q8 Net-_Q10-Pad2_ Net-_Q5-Pad1_ Net-_Q8-Pad3_ eSim_NPN
Q11 Net-_Q11-Pad1_ Net-_Q10-Pad1_ Net-_Q11-Pad3_ eSim_NPN
Q12 Net-_C1-Pad2_ Net-_Q12-Pad2_ Net-_Q11-Pad1_ eSim_PNP
R8 Net-_Q10-Pad2_ Net-_Q10-Pad3_ 12.4k
Q10 Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_PNP
Q15 Net-_C1-Pad2_ Net-_C1-Pad1_ Net-_Q13-Pad2_ eSim_PNP
Q14 Net-_Q13-Pad2_ Net-_Q1-Pad2_ Net-_Q14-Pad3_ eSim_PNP
R13 Net-_C1-Pad2_ Net-_Q12-Pad2_ 5.1k
C2 Net-_C1-Pad1_ Net-_C2-Pad2_ 30p
C1 Net-_C1-Pad1_ Net-_C1-Pad2_ 30p
R20 Net-_Q22-Pad2_ Net-_Q11-Pad1_ 12k
Q23 Net-_Q22-Pad1_ Net-_Q22-Pad2_ Net-_Q23-Pad3_ eSim_NPN
Q22 Net-_Q22-Pad1_ Net-_Q22-Pad2_ Net-_Q22-Pad3_ eSim_NPN
R26 Net-_Q28-Pad3_ Net-_Q22-Pad3_ 3
R25 Net-_Q28-Pad3_ Net-_C1-Pad2_ 0.03
U5 Net-_J1-Pad1_ Net-_C1-Pad2_ Net-_R17-Pad1_ PORT
R28 Net-_Q23-Pad3_ Net-_Q22-Pad3_ 160
R27 Net-_R27-Pad1_ Net-_R27-Pad2_ 18k
U4 Net-_Q23-Pad3_ Net-_R27-Pad2_ zener
Q18 Net-_Q16-Pad2_ Net-_Q16-Pad2_ Net-_Q11-Pad1_ eSim_PNP
Q20 Net-_C1-Pad2_ Net-_C3-Pad1_ Net-_Q11-Pad1_ eSim_PNP
Q21 Net-_C3-Pad1_ Net-_C3-Pad2_ Net-_C1-Pad2_ eSim_NPN
R16 Net-_Q17-Pad3_ Net-_Q19-Pad3_ 2.4k
R15 Net-_C2-Pad2_ Net-_Q17-Pad3_ 12k
R17 Net-_R17-Pad1_ Net-_C2-Pad2_ 50
U2 Net-_C2-Pad2_ Net-_C1-Pad2_ zener
Q17 Net-_C1-Pad1_ Net-_C1-Pad2_ Net-_Q17-Pad3_ eSim_NPN
Q19 Net-_Q16-Pad2_ Net-_C1-Pad2_ Net-_Q19-Pad3_ eSim_NPN
Q16 Net-_C1-Pad1_ Net-_Q16-Pad2_ Net-_Q11-Pad1_ eSim_PNP
R21 Net-_Q22-Pad2_ Net-_Q22-Pad1_ 400
Q25 Net-_Q24-Pad2_ Net-_Q24-Pad2_ Net-_J1-Pad1_ eSim_PNP
Q24 Net-_Q11-Pad1_ Net-_Q24-Pad2_ Net-_J1-Pad1_ eSim_PNP
Q27 Net-_J1-Pad1_ Net-_Q27-Pad2_ Net-_Q27-Pad3_ eSim_NPN
R24 Net-_Q27-Pad3_ Net-_C1-Pad2_ 160
Q28 Net-_J1-Pad1_ Net-_Q27-Pad3_ Net-_Q28-Pad3_ eSim_NPN
Q26 Net-_Q24-Pad2_ Net-_Q11-Pad1_ Net-_Q26-Pad3_ eSim_NPN
R23 Net-_Q27-Pad2_ Net-_Q11-Pad1_ 370
R22 Net-_Q27-Pad3_ Net-_Q26-Pad3_ 130
U3 Net-_R27-Pad1_ Net-_J1-Pad1_ zener
R19 Net-_Q22-Pad1_ Net-_C3-Pad2_ 13k
C3 Net-_C3-Pad1_ Net-_C3-Pad2_ 5p
R18 Net-_C3-Pad1_ Net-_Q11-Pad1_ 6.7k
.end
