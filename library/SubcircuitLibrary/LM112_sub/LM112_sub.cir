.title KiCad schematic
Q18 Net-_Q18-Pad1_ Net-_Q18-Pad1_ Net-_J1-Pad2_ eSim_NPN
R8 Net-_Q11-Pad1_ Net-_C1-Pad1_ 2k
Q11 Net-_Q11-Pad1_ Net-_C1-Pad2_ Net-_Q11-Pad3_ eSim_PNP
Q23 Net-_Q15-Pad3_ Net-_Q17-Pad1_ Net-_Q22-Pad1_ eSim_NPN
Q8 Net-_C1-Pad2_ Net-_Q13-Pad1_ Net-_Q8-Pad3_ eSim_NPN
Q13 Net-_Q13-Pad1_ Net-_Q13-Pad1_ Net-_Q12-Pad3_ eSim_NPN
R6 Net-_Q12-Pad3_ Net-_Q4-Pad1_ 200k
R9 Net-_Q15-Pad3_ Net-_Q14-Pad3_ 10k
Q14 Net-_Q13-Pad1_ Net-_J1-Pad1_ Net-_Q14-Pad3_ eSim_PNP
R7 Net-_Q15-Pad3_ Net-_Q11-Pad3_ 7k
U1 Net-_Q7-Pad1_ Net-_Q1-Pad2_ Net-_Q4-Pad3_ Net-_J1-Pad2_ Net-_Q11-Pad1_ Net-_Q27-Pad3_ Net-_Q15-Pad3_ Net-_Q2-Pad1_ PORT
Q7 Net-_Q7-Pad1_ Net-_Q7-Pad1_ Net-_Q15-Pad3_ eSim_PNP
Q2 Net-_Q2-Pad1_ Net-_Q2-Pad1_ Net-_Q15-Pad3_ eSim_PNP
Q15 Net-_J1-Pad1_ Net-_J1-Pad1_ Net-_Q15-Pad3_ eSim_PNP
Q17 Net-_Q17-Pad1_ Net-_J1-Pad1_ Net-_Q15-Pad3_ eSim_PNP
R16 Net-_Q17-Pad1_ Net-_Q24-Pad1_ 2k
Q28 Net-_Q15-Pad3_ Net-_Q24-Pad1_ Net-_Q28-Pad3_ eSim_NPN
Q25 Net-_J1-Pad2_ Net-_J1-Pad2_ Net-_Q24-Pad3_ eSim_PNP
Q22 Net-_Q22-Pad1_ Net-_Q11-Pad1_ Net-_J1-Pad2_ eSim_NPN
Q20 Net-_Q11-Pad1_ Net-_Q18-Pad1_ Net-_J1-Pad2_ eSim_NPN
Q24 Net-_Q24-Pad1_ Net-_Q17-Pad1_ Net-_Q24-Pad3_ eSim_NPN
R1 Net-_Q2-Pad1_ Net-_Q3-Pad1_ 20k
Q5 Net-_Q18-Pad1_ Net-_Q3-Pad1_ Net-_Q11-Pad3_ eSim_PNP
R3 Net-_Q7-Pad1_ Net-_C1-Pad2_ 20k
C1 Net-_C1-Pad1_ Net-_C1-Pad2_ 180p
Q29 Net-_J1-Pad2_ Net-_J1-Pad2_ Net-_Q27-Pad3_ eSim_PNP
R18 Net-_Q28-Pad3_ Net-_Q27-Pad2_ 200
R20 Net-_Q27-Pad2_ Net-_Q27-Pad3_ 100
R19 Net-_Q27-Pad2_ Net-_Q27-Pad3_ 250
Q27 Net-_Q24-Pad1_ Net-_Q27-Pad2_ Net-_Q27-Pad3_ eSim_NPN
U2 Net-_Q26-Pad1_ Net-_Q15-Pad3_ zener
Q10 Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
R5 Net-_Q10-Pad3_ Net-_R10-Pad2_ 6.8k
Q9 Net-_Q8-Pad3_ Net-_Q4-Pad3_ Net-_Q9-Pad3_ eSim_NPN
R4 Net-_Q9-Pad3_ Net-_Q10-Pad1_ 2k
R2 Net-_Q1-Pad3_ Net-_Q10-Pad1_ 2k
Q12 Net-_J1-Pad2_ Net-_Q10-Pad1_ Net-_Q12-Pad3_ eSim_PNP
J1 Net-_J1-Pad1_ Net-_J1-Pad2_ Net-_J1-Pad3_ jfet_p
R12 Net-_J1-Pad3_ Net-_Q16-Pad2_ 1k
Q16 Net-_J1-Pad1_ Net-_Q16-Pad2_ Net-_Q10-Pad2_ eSim_NPN
R14 Net-_J1-Pad2_ Net-_Q19-Pad2_ 20k
Q21 Net-_J1-Pad1_ Net-_J1-Pad3_ Net-_Q19-Pad2_ eSim_NPN
R11 Net-_Q19-Pad3_ Net-_R10-Pad2_ 500
R10 Net-_Q10-Pad2_ Net-_R10-Pad2_ 70k
Q19 Net-_Q16-Pad2_ Net-_Q19-Pad2_ Net-_Q19-Pad3_ eSim_NPN
R13 Net-_Q19-Pad2_ Net-_Q19-Pad3_ 20k
Q26 Net-_Q26-Pad1_ Net-_J1-Pad2_ Net-_Q26-Pad3_ eSim_NPN
R17 Net-_Q26-Pad3_ Net-_J1-Pad2_ 2k
R15 Net-_J1-Pad2_ Net-_Q19-Pad3_ 2.7k
Q6 Net-_Q4-Pad1_ Net-_Q4-Pad3_ Net-_Q1-Pad2_ eSim_NPN
Q3 Net-_Q3-Pad1_ Net-_Q13-Pad1_ Net-_Q1-Pad1_ eSim_NPN
Q4 Net-_Q4-Pad1_ Net-_Q1-Pad2_ Net-_Q4-Pad3_ eSim_NPN
Q1 Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
.end
