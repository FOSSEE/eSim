.title KiCad schematic
U1 Net-_Q5-Pad2_ Net-_Q1-Pad2_ Net-_Q6-Pad2_ Net-_D9-Pad2_ Net-_Q11-Pad3_ Net-_Q11-Pad1_ Net-_D6-Pad1_ Net-_Q10-Pad2_ Net-_I3-Pad1_ GND PORT
Q8 Net-_D6-Pad1_ Net-_D5-Pad2_ Net-_Q8-Pad3_ eSim_PNP
I5 Net-_I5-Pad1_ Net-_D9-Pad2_ 1m
Q10 GND Net-_Q10-Pad2_ Net-_I5-Pad1_ eSim_NPN
Q9 Net-_Q8-Pad3_ Net-_I3-Pad1_ Net-_I5-Pad1_ eSim_NPN
R7 Net-_Q8-Pad3_ GND 100
R6 Net-_D5-Pad1_ GND 100
D5 Net-_D5-Pad1_ Net-_D5-Pad2_ eSim_Diode
Q1 Net-_D1-Pad1_ Net-_Q1-Pad2_ GND eSim_PNP
R3 Net-_Q2-Pad2_ Net-_D3-Pad2_ 12k
D2 Net-_D2-Pad1_ Net-_D2-Pad2_ eSim_Diode
D3 Net-_D2-Pad2_ Net-_D3-Pad2_ eSim_Diode
R2 Net-_D2-Pad1_ GND 1k
Q6 GND Net-_Q6-Pad2_ Net-_I3-Pad1_ eSim_NPN
I4 Net-_D5-Pad2_ Net-_D9-Pad2_ 1m
I2 Net-_I2-Pad1_ Net-_D9-Pad2_ 1m
I3 Net-_I3-Pad1_ Net-_D9-Pad2_ 1m
Q12 Net-_Q11-Pad1_ Net-_D6-Pad1_ Net-_Q11-Pad2_ eSim_NPN
D6 Net-_D6-Pad1_ Net-_D6-Pad2_ eSim_Diode
D7 Net-_D6-Pad2_ Net-_D7-Pad2_ eSim_Diode
Q11 Net-_Q11-Pad1_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_NPN
D8 Net-_D7-Pad2_ Net-_D8-Pad2_ eSim_Diode
D9 Net-_D8-Pad2_ Net-_D9-Pad2_ eSim_Diode
R5 Net-_Q4-Pad1_ GND 6.8k
Q2 GND Net-_Q2-Pad2_ Net-_Q2-Pad3_ eSim_NPN
Q5 GND Net-_Q5-Pad2_ Net-_Q4-Pad2_ eSim_NPN
Q7 Net-_Q6-Pad2_ Net-_D5-Pad2_ Net-_Q4-Pad1_ eSim_PNP
Q4 Net-_Q4-Pad1_ Net-_Q4-Pad2_ Net-_I2-Pad1_ eSim_NPN
Q3 GND Net-_Q2-Pad3_ Net-_I2-Pad1_ eSim_NPN
U2 Net-_D1-Pad2_ GND zener
U3 Net-_D1-Pad1_ GND zener
D4 Net-_D4-Pad1_ Net-_D1-Pad1_ eSim_Diode
R4 Net-_D4-Pad1_ Net-_Q2-Pad2_ 12k
R1 Net-_D9-Pad2_ Net-_D1-Pad2_ 3k
I1 Net-_D1-Pad1_ Net-_D9-Pad2_ 1m
D1 Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
.end
