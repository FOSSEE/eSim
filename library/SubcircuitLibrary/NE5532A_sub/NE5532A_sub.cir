.title KiCad schematic
Q25 Net-_C2-Pad2_ Net-_Q25-Pad2_ Net-_Q11-Pad2_ eSim_NPN
R16 Net-_Q25-Pad2_ Net-_Q11-Pad2_ 1k
Q31 Net-_Q25-Pad2_ Net-_Q25-Pad2_ Net-_Q11-Pad2_ eSim_NPN
R18 Net-_Q28-Pad3_ Net-_Q27-Pad1_ 100
Q29 Net-_Q25-Pad2_ Net-_Q27-Pad1_ Net-_Q28-Pad3_ eSim_PNP
U1 Net-_Q28-Pad3_ Net-_Q1-Pad3_ Net-_Q1-Pad1_ Net-_Q11-Pad2_ Net-_C1-Pad1_ PORT
Q19 Net-_Q19-Pad1_ Net-_C2-Pad2_ Net-_Q19-Pad3_ eSim_NPN
R13 Net-_Q19-Pad3_ Net-_Q11-Pad2_ 1k
Q23 Net-_C3-Pad2_ Net-_Q19-Pad3_ Net-_Q11-Pad2_ eSim_NPN
Q22 Net-_Q22-Pad1_ Net-_Q20-Pad1_ Net-_C1-Pad1_ eSim_PNP
R17 Net-_Q28-Pad2_ Net-_Q28-Pad3_ 100
Q30 Net-_C1-Pad1_ Net-_Q19-Pad1_ Net-_Q28-Pad2_ eSim_NPN
Q28 Net-_Q19-Pad1_ Net-_Q28-Pad2_ Net-_Q28-Pad3_ eSim_NPN
R15 Net-_Q22-Pad1_ Net-_Q19-Pad1_ 47k
Q24 Net-_Q19-Pad1_ Net-_Q19-Pad1_ Net-_Q24-Pad3_ eSim_NPN
Q26 Net-_Q19-Pad1_ Net-_Q24-Pad3_ Net-_C3-Pad2_ eSim_NPN
Q21 Net-_Q11-Pad2_ Net-_C3-Pad2_ Net-_C2-Pad2_ eSim_PNP
R14 Net-_Q24-Pad3_ Net-_C3-Pad2_ 1k
Q27 Net-_Q27-Pad1_ Net-_Q27-Pad1_ Net-_C3-Pad2_ eSim_NPN
Q17 Net-_C2-Pad2_ Net-_Q14-Pad2_ Net-_Q17-Pad3_ eSim_NPN
R12 Net-_Q17-Pad3_ Net-_Q11-Pad2_ 1k
R10 Net-_Q14-Pad2_ Net-_Q11-Pad2_ 1k
Q16 Net-_C1-Pad1_ Net-_Q13-Pad1_ Net-_C2-Pad2_ eSim_NPN
Q15 Net-_C1-Pad1_ Net-_Q13-Pad1_ Net-_Q14-Pad2_ eSim_NPN
C2 Net-_C2-Pad1_ Net-_C2-Pad2_ 37p
C3 Net-_C2-Pad1_ Net-_C3-Pad2_ 14p
C4 Net-_C2-Pad2_ Net-_C3-Pad2_ 7p
Q18 Net-_C2-Pad2_ Net-_C1-Pad2_ Net-_Q18-Pad3_ eSim_PNP
R11 Net-_C1-Pad1_ Net-_Q18-Pad3_ 3k
Q20 Net-_Q20-Pad1_ Net-_Q20-Pad1_ Net-_C1-Pad1_ eSim_PNP
Q6 Net-_C2-Pad1_ Net-_Q1-Pad1_ Net-_Q4-Pad3_ eSim_NPN
Q7 Net-_Q10-Pad2_ Net-_Q10-Pad1_ Net-_Q7-Pad3_ eSim_PNP
Q10 Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
R5 Net-_Q10-Pad2_ Net-_Q11-Pad3_ 10k
Q5 Net-_Q4-Pad3_ Net-_Q10-Pad2_ Net-_Q5-Pad3_ eSim_NPN
Q13 Net-_Q13-Pad1_ Net-_C2-Pad1_ Net-_Q13-Pad3_ eSim_PNP
R8 Net-_C1-Pad1_ Net-_Q13-Pad3_ 100k
Q11 Net-_C1-Pad1_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_NPN
R3 Net-_C2-Pad1_ Net-_D2-Pad2_ 100k
D2 Net-_D1-Pad2_ Net-_D2-Pad2_ eSim_Diode
D1 Net-_C1-Pad1_ Net-_D1-Pad2_ eSim_Diode
Q9 Net-_Q10-Pad1_ Net-_Q10-Pad1_ Net-_Q9-Pad3_ eSim_PNP
R6 Net-_Q20-Pad1_ Net-_Q9-Pad3_ 10k
R4 Net-_Q20-Pad1_ Net-_Q7-Pad3_ 10k
C1 Net-_C1-Pad1_ Net-_C1-Pad2_ 36p
R1 Net-_C1-Pad2_ Net-_D2-Pad2_ 100k
Q1 Net-_Q1-Pad1_ Net-_Q1-Pad1_ Net-_Q1-Pad3_ eSim_NPN
Q3 Net-_Q1-Pad3_ Net-_Q1-Pad3_ Net-_Q1-Pad1_ eSim_NPN
Q4 Net-_C1-Pad2_ Net-_Q1-Pad3_ Net-_Q4-Pad3_ eSim_NPN
Q2 Net-_C1-Pad2_ Net-_C1-Pad2_ Net-_C1-Pad1_ eSim_NPN
Q14 Net-_Q13-Pad1_ Net-_Q14-Pad2_ Net-_Q14-Pad3_ eSim_NPN
R9 Net-_Q14-Pad3_ Net-_Q11-Pad2_ 1k
R7 Net-_Q10-Pad3_ Net-_Q11-Pad2_ 10k
R2 Net-_Q5-Pad3_ Net-_Q11-Pad2_ 460
Q8 Net-_Q10-Pad2_ Net-_Q10-Pad2_ Net-_Q11-Pad2_ eSim_NPN
Q12 Net-_Q11-Pad3_ Net-_Q11-Pad3_ Net-_Q11-Pad2_ eSim_NPN
.end
