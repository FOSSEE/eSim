.title KiCad schematic
Q13 Net-_I10-Pad2_ Net-_C1-Pad1_ Net-_I5-Pad1_ eSim_PNP
U1 Net-_I5-Pad1_ Net-_Q1-Pad2_ Net-_Q6-Pad2_ Net-_I10-Pad2_ Net-_Q19-Pad2_ Net-_Q14-Pad2_ Net-_I10-Pad1_ Net-_I1-Pad1_ PORT
Q12 Net-_I1-Pad1_ Net-_Q11-Pad3_ Net-_Q10-Pad2_ eSim_NPN
Q3 Net-_Q2-Pad1_ Net-_Q2-Pad1_ Net-_I10-Pad2_ eSim_NPN
Q4 Net-_C1-Pad2_ Net-_Q2-Pad1_ Net-_I10-Pad2_ eSim_NPN
Q7 Net-_I10-Pad2_ Net-_C1-Pad2_ Net-_I2-Pad2_ eSim_PNP
Q11 Net-_I1-Pad1_ Net-_C1-Pad1_ Net-_Q11-Pad3_ eSim_NPN
R1 Net-_I5-Pad1_ Net-_Q10-Pad2_ 2
I4 Net-_I1-Pad1_ Net-_C1-Pad1_ 100u
Q10 Net-_C1-Pad1_ Net-_Q10-Pad2_ Net-_I5-Pad1_ eSim_NPN
I5 Net-_I5-Pad1_ Net-_I10-Pad2_ 50u
Q9 Net-_C1-Pad1_ Net-_I3-Pad1_ Net-_I10-Pad2_ eSim_NPN
I3 Net-_I3-Pad1_ Net-_I10-Pad2_ 50u
Q8 Net-_I1-Pad1_ Net-_I2-Pad2_ Net-_I3-Pad1_ eSim_NPN
I2 Net-_I1-Pad1_ Net-_I2-Pad2_ 4u
Q6 Net-_I10-Pad2_ Net-_Q6-Pad2_ Net-_Q5-Pad2_ eSim_PNP
Q1 Net-_I10-Pad2_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_PNP
C1 Net-_C1-Pad1_ Net-_C1-Pad2_ 10pf
Q2 Net-_Q2-Pad1_ Net-_Q1-Pad3_ Net-_I1-Pad2_ eSim_PNP
Q5 Net-_C1-Pad2_ Net-_Q5-Pad2_ Net-_I1-Pad2_ eSim_PNP
I1 Net-_I1-Pad1_ Net-_I1-Pad2_ 6u
I9 Net-_I1-Pad1_ Net-_C2-Pad1_ 100u
R2 Net-_I10-Pad1_ Net-_Q23-Pad2_ 2
Q24 Net-_I1-Pad1_ Net-_C2-Pad1_ Net-_Q24-Pad3_ eSim_NPN
Q25 Net-_I1-Pad1_ Net-_Q24-Pad3_ Net-_Q23-Pad2_ eSim_NPN
Q23 Net-_C2-Pad1_ Net-_Q23-Pad2_ Net-_I10-Pad1_ eSim_NPN
Q19 Net-_I10-Pad2_ Net-_Q19-Pad2_ Net-_Q18-Pad2_ eSim_PNP
Q14 Net-_I10-Pad2_ Net-_Q14-Pad2_ Net-_Q14-Pad3_ eSim_PNP
Q15 Net-_Q15-Pad1_ Net-_Q14-Pad3_ Net-_I6-Pad2_ eSim_PNP
I6 Net-_I1-Pad1_ Net-_I6-Pad2_ 6u
Q18 Net-_C2-Pad2_ Net-_Q18-Pad2_ Net-_I6-Pad2_ eSim_PNP
I7 Net-_I1-Pad1_ Net-_I7-Pad2_ 4u
C2 Net-_C2-Pad1_ Net-_C2-Pad2_ 10pf
Q20 Net-_I10-Pad2_ Net-_C2-Pad2_ Net-_I7-Pad2_ eSim_PNP
Q17 Net-_C2-Pad2_ Net-_Q15-Pad1_ Net-_I10-Pad2_ eSim_NPN
I8 Net-_I8-Pad1_ Net-_I10-Pad2_ 50u
Q21 Net-_I1-Pad1_ Net-_I7-Pad2_ Net-_I8-Pad1_ eSim_NPN
Q16 Net-_Q15-Pad1_ Net-_Q15-Pad1_ Net-_I10-Pad2_ eSim_NPN
Q26 Net-_I10-Pad2_ Net-_C2-Pad1_ Net-_I10-Pad1_ eSim_PNP
Q22 Net-_C2-Pad1_ Net-_I8-Pad1_ Net-_I10-Pad2_ eSim_NPN
I10 Net-_I10-Pad1_ Net-_I10-Pad2_ 50u
.end
