.title KiCad schematic
Q11 Net-_Q9-Pad2_ Net-_Q9-Pad2_ Net-_Q11-Pad3_ eSim_NPN
R6 Net-_Q9-Pad2_ Net-_Q10-Pad3_ 2.7k
Q9 Net-_C1-Pad1_ Net-_Q9-Pad2_ Net-_J1-Pad3_ eSim_PNP
R5 Net-_J1-Pad1_ Net-_Q13-Pad2_ 7.5k
J1 Net-_J1-Pad1_ Net-_C1-Pad1_ Net-_J1-Pad3_ jfet_n
U2 Net-_U2-PadIN_ Net-_U2-PadOUT_ zener
Q10 Net-_Q10-Pad1_ Net-_J1-Pad3_ Net-_Q10-Pad3_ eSim_NPN
Q12 Net-_Q12-Pad1_ Net-_J1-Pad3_ Net-_Q10-Pad3_ eSim_NPN
R2 Net-_Q5-Pad1_ Net-_Q4-Pad3_ 7.8k
Q5 Net-_Q5-Pad1_ Net-_Q5-Pad1_ Net-_Q6-Pad3_ eSim_NPN
Q4 Net-_Q2-Pad2_ Net-_Q1-Pad3_ Net-_Q4-Pad3_ eSim_NPN
Q6 Net-_Q2-Pad2_ Net-_Q4-Pad3_ Net-_Q6-Pad3_ eSim_NPN
U1 Net-_J1-Pad1_ Net-_Q1-Pad3_ Net-_U2-PadIN_ Net-_C1-Pad1_ Net-_C1-Pad1_ Net-_Q11-Pad3_ Net-_Q23-Pad1_ Net-_R14-Pad2_ Net-_J1-Pad1_ PORT
R3 Net-_U2-PadIN_ Net-_Q6-Pad3_ 7k
Q3 Net-_Q3-Pad1_ Net-_Q3-Pad1_ Net-_Q1-Pad3_ eSim_NPN
R1 Net-_Q3-Pad1_ Net-_Q1-Pad2_ 2.3k
Q1 Net-_J1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
Q2 Net-_J1-Pad1_ Net-_Q2-Pad2_ Net-_Q1-Pad2_ eSim_NPN
Q7 Net-_J1-Pad1_ Net-_U2-PadOUT_ Net-_Q7-Pad3_ eSim_NPN
R4 Net-_Q2-Pad2_ Net-_Q7-Pad3_ 14k
Q8 Net-_U2-PadOUT_ Net-_Q10-Pad1_ Net-_J1-Pad1_ eSim_PNP
Q17 Net-_Q15-Pad2_ Net-_Q15-Pad2_ Net-_Q11-Pad3_ eSim_NPN
C2 Net-_C2-Pad1_ Net-_C2-Pad2_ 5p
R10 Net-_Q22-Pad3_ Net-_Q11-Pad3_ 3k
Q19 Net-_C2-Pad1_ Net-_Q19-Pad2_ Net-_C1-Pad1_ eSim_NPN
Q20 Net-_C1-Pad1_ Net-_C2-Pad2_ Net-_C1-Pad1_ eSim_NPN
R8 Net-_Q11-Pad3_ Net-_C2-Pad2_ 2.2k
R7 Net-_C1-Pad1_ Net-_C2-Pad1_ 2.2k
C1 Net-_C1-Pad1_ Net-_C1-Pad1_ 15p
Q23 Net-_Q23-Pad1_ Net-_Q22-Pad3_ Net-_Q11-Pad3_ eSim_NPN
Q22 Net-_Q21-Pad1_ Net-_Q19-Pad2_ Net-_Q22-Pad3_ eSim_NPN
R14 Net-_Q23-Pad1_ Net-_R14-Pad2_ 1k
R9 Net-_Q19-Pad2_ Net-_Q22-Pad3_ 80k
Q14 Net-_Q15-Pad1_ Net-_Q12-Pad1_ Net-_Q14-Pad3_ eSim_PNP
Q13 Net-_J1-Pad1_ Net-_Q13-Pad2_ Net-_Q14-Pad3_ eSim_NPN
Q15 Net-_Q15-Pad1_ Net-_Q15-Pad2_ Net-_Q11-Pad3_ eSim_NPN
Q16 Net-_C2-Pad1_ Net-_Q15-Pad1_ Net-_Q15-Pad2_ eSim_NPN
Q21 Net-_Q21-Pad1_ Net-_C2-Pad1_ Net-_Q19-Pad2_ eSim_NPN
Q17_1 Net-_C2-Pad1_ Net-_Q12-Pad1_ Net-_Q17_1-Pad3_ eSim_PNP
Q18 Net-_J1-Pad1_ Net-_Q18-Pad2_ Net-_Q17_1-Pad3_ eSim_NPN
R12 Net-_Q18-Pad2_ Net-_J1-Pad1_ 15k
R13 Net-_R14-Pad2_ Net-_Q18-Pad2_ 15k
R11 Net-_Q21-Pad1_ Net-_J1-Pad1_ 2k
.end
