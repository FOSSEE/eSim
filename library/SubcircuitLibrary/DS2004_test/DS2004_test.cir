.title KiCad schematic
Q11 Net-_D7-Pad1_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_NPN
Q14 Net-_D7-Pad1_ Net-_Q11-Pad3_ Net-_Q12-Pad3_ eSim_NPN
R21 Net-_Q11-Pad3_ Net-_Q12-Pad3_ 3k
R18 Net-_Q11-Pad2_ Net-_Q11-Pad3_ 7.2k
U1 Net-_R1-Pad1_ Net-_R2-Pad1_ Net-_R3-Pad1_ Net-_R4-Pad1_ Net-_R14-Pad1_ Net-_R15-Pad1_ Net-_R13-Pad1_ Net-_Q12-Pad3_ Net-_D1-Pad2_ Net-_D5-Pad1_ Net-_D7-Pad1_ Net-_D6-Pad1_ Net-_D4-Pad1_ Net-_D3-Pad1_ Net-_D2-Pad1_ Net-_D1-Pad1_ PORT
R14 Net-_R14-Pad1_ Net-_Q10-Pad2_ 10.5k
R15 Net-_R15-Pad1_ Net-_Q11-Pad2_ 10.5k
D1 Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
Q9 Net-_D5-Pad1_ Net-_Q9-Pad2_ Net-_Q12-Pad2_ eSim_NPN
R19 Net-_Q12-Pad2_ Net-_Q12-Pad3_ 3k
D5 Net-_D5-Pad1_ Net-_D1-Pad2_ eSim_Diode
Q12 Net-_D5-Pad1_ Net-_Q12-Pad2_ Net-_Q12-Pad3_ eSim_NPN
R13 Net-_R13-Pad1_ Net-_Q9-Pad2_ 10.5k
R16 Net-_Q9-Pad2_ Net-_Q12-Pad2_ 7.2k
D7 Net-_D7-Pad1_ Net-_D1-Pad2_ eSim_Diode
Q13 Net-_D6-Pad1_ Net-_Q10-Pad3_ Net-_Q12-Pad3_ eSim_NPN
R20 Net-_Q10-Pad3_ Net-_Q12-Pad3_ 3k
Q10 Net-_D6-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
R17 Net-_Q10-Pad2_ Net-_Q10-Pad3_ 7.2k
D6 Net-_D6-Pad1_ Net-_D1-Pad2_ eSim_Diode
D4 Net-_D4-Pad1_ Net-_D1-Pad2_ eSim_Diode
Q8 Net-_D4-Pad1_ Net-_Q4-Pad3_ Net-_Q12-Pad3_ eSim_NPN
Q7 Net-_D3-Pad1_ Net-_Q3-Pad3_ Net-_Q12-Pad3_ eSim_NPN
R12 Net-_Q4-Pad3_ Net-_Q12-Pad3_ 3k
R8 Net-_Q4-Pad2_ Net-_Q4-Pad3_ 7.2k
Q4 Net-_D4-Pad1_ Net-_Q4-Pad2_ Net-_Q4-Pad3_ eSim_NPN
Q3 Net-_D3-Pad1_ Net-_Q3-Pad2_ Net-_Q3-Pad3_ eSim_NPN
R11 Net-_Q3-Pad3_ Net-_Q12-Pad3_ 3k
R7 Net-_Q3-Pad2_ Net-_Q3-Pad3_ 7.2k
R4 Net-_R4-Pad1_ Net-_Q4-Pad2_ 10.5k
Q2 Net-_D2-Pad1_ Net-_Q2-Pad2_ Net-_Q2-Pad3_ eSim_NPN
R6 Net-_Q2-Pad2_ Net-_Q2-Pad3_ 7.2k
R3 Net-_R3-Pad1_ Net-_Q3-Pad2_ 10.5k
D3 Net-_D3-Pad1_ Net-_D1-Pad2_ eSim_Diode
Q5 Net-_D1-Pad1_ Net-_Q1-Pad3_ Net-_Q12-Pad3_ eSim_NPN
D2 Net-_D2-Pad1_ Net-_D1-Pad2_ eSim_Diode
R10 Net-_Q2-Pad3_ Net-_Q12-Pad3_ 3k
Q6 Net-_D2-Pad1_ Net-_Q2-Pad3_ Net-_Q12-Pad3_ eSim_NPN
Q1 Net-_D1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
R2 Net-_R2-Pad1_ Net-_Q2-Pad2_ 10.5k
R1 Net-_R1-Pad1_ Net-_Q1-Pad2_ 10.5k
R9 Net-_Q1-Pad3_ Net-_Q12-Pad3_ 3k
R5 Net-_Q1-Pad2_ Net-_Q1-Pad3_ 7.2k
U2 Net-_R22-Pad2_ GND plot_i2
U3 Net-_R23-Pad2_ GND plot_i2
U4 Net-_R24-Pad2_ GND plot_i2
U6 Net-_R26-Pad2_ GND plot_i2
U5 Net-_R25-Pad2_ GND plot_i2
v1 A_IN GND DC
v2 B_IN GND DC
U10 A_IN plot_v1
U11 B_IN plot_v1
U12 C_IN plot_v1
v3 C_IN GND DC
v4 D_IN GND DC
U7 Net-_R27-Pad2_ GND plot_i2
U8 Net-_R28-Pad2_ GND plot_i2
U9 Net-_R29-Pad2_ GND plot_i2
R27 C Net-_R27-Pad2_ 1.7k
R28 B Net-_R28-Pad2_ 1.7k
R29 A Net-_R29-Pad2_ 1.7k
R26 D Net-_R26-Pad2_ 1.7k
R24 F Net-_R24-Pad2_ 1.7k
R25 E Net-_R25-Pad2_ 1.7k
X1 A_IN B_IN C_IN D_IN E_IN F_IN G_IN GND COM G F E D C B A DS2004
U16 G_IN plot_v1
R22 COM Net-_R22-Pad2_ 1.7k
R23 G Net-_R23-Pad2_ 1.7k
v7 G_IN GND DC
v6 F_IN GND DC
v5 E_IN GND DC
U14 E_IN plot_v1
U15 F_IN plot_v1
U13 D_IN plot_v1
.end
