.title KiCad schematic
D6 Net-_D6-Pad1_ Net-_D1-Pad2_ eSim_Diode
U1 Net-_R1-Pad1_ Net-_R2-Pad1_ Net-_R3-Pad1_ Net-_R4-Pad1_ Net-_R14-Pad1_ Net-_R15-Pad1_ Net-_R13-Pad1_ Net-_Q12-Pad3_ Net-_D1-Pad2_ Net-_D5-Pad1_ Net-_D7-Pad1_ Net-_D6-Pad1_ Net-_D4-Pad1_ Net-_D3-Pad1_ Net-_D2-Pad1_ Net-_D1-Pad1_ PORT
Q10 Net-_D6-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
R14 Net-_R14-Pad1_ Net-_Q10-Pad2_ 10.5k
R20 Net-_Q10-Pad3_ Net-_Q12-Pad3_ 3k
Q13 Net-_D6-Pad1_ Net-_Q10-Pad3_ Net-_Q12-Pad3_ eSim_NPN
R17 Net-_Q10-Pad2_ Net-_Q10-Pad3_ 7.2k
R15 Net-_R15-Pad1_ Net-_Q11-Pad2_ 10.5k
D7 Net-_D7-Pad1_ Net-_D1-Pad2_ eSim_Diode
R21 Net-_Q11-Pad3_ Net-_Q12-Pad3_ 3k
Q14 Net-_D7-Pad1_ Net-_Q11-Pad3_ Net-_Q12-Pad3_ eSim_NPN
Q11 Net-_D7-Pad1_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_NPN
R18 Net-_Q11-Pad2_ Net-_Q11-Pad3_ 7.2k
Q12 Net-_D5-Pad1_ Net-_Q12-Pad2_ Net-_Q12-Pad3_ eSim_NPN
R13 Net-_R13-Pad1_ Net-_Q9-Pad2_ 10.5k
D5 Net-_D5-Pad1_ Net-_D1-Pad2_ eSim_Diode
Q9 Net-_D5-Pad1_ Net-_Q9-Pad2_ Net-_Q12-Pad2_ eSim_NPN
R19 Net-_Q12-Pad2_ Net-_Q12-Pad3_ 3k
R16 Net-_Q9-Pad2_ Net-_Q12-Pad2_ 7.2k
Q7 Net-_D3-Pad1_ Net-_Q3-Pad3_ Net-_Q12-Pad3_ eSim_NPN
D4 Net-_D4-Pad1_ Net-_D1-Pad2_ eSim_Diode
Q8 Net-_D4-Pad1_ Net-_Q4-Pad3_ Net-_Q12-Pad3_ eSim_NPN
D3 Net-_D3-Pad1_ Net-_D1-Pad2_ eSim_Diode
D1 Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
Q6 Net-_D2-Pad1_ Net-_Q2-Pad3_ Net-_Q12-Pad3_ eSim_NPN
Q1 Net-_D1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
Q5 Net-_D1-Pad1_ Net-_Q1-Pad3_ Net-_Q12-Pad3_ eSim_NPN
D2 Net-_D2-Pad1_ Net-_D1-Pad2_ eSim_Diode
Q2 Net-_D2-Pad1_ Net-_Q2-Pad2_ Net-_Q2-Pad3_ eSim_NPN
R6 Net-_Q2-Pad2_ Net-_Q2-Pad3_ 7.2k
R10 Net-_Q2-Pad3_ Net-_Q12-Pad3_ 3k
R9 Net-_Q1-Pad3_ Net-_Q12-Pad3_ 3k
R5 Net-_Q1-Pad2_ Net-_Q1-Pad3_ 7.2k
R1 Net-_R1-Pad1_ Net-_Q1-Pad2_ 10.5k
R2 Net-_R2-Pad1_ Net-_Q2-Pad2_ 10.5k
R11 Net-_Q3-Pad3_ Net-_Q12-Pad3_ 3k
Q3 Net-_D3-Pad1_ Net-_Q3-Pad2_ Net-_Q3-Pad3_ eSim_NPN
R3 Net-_R3-Pad1_ Net-_Q3-Pad2_ 10.5k
R12 Net-_Q4-Pad3_ Net-_Q12-Pad3_ 3k
Q4 Net-_D4-Pad1_ Net-_Q4-Pad2_ Net-_Q4-Pad3_ eSim_NPN
R8 Net-_Q4-Pad2_ Net-_Q4-Pad3_ 7.2k
R7 Net-_Q3-Pad2_ Net-_Q3-Pad3_ 7.2k
R4 Net-_R4-Pad1_ Net-_Q4-Pad2_ 10.5k
.end
