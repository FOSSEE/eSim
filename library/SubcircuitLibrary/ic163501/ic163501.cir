* C:\Users\Chaithu\FOSSEE\eSim\library\SubcircuitLibrary\ic163501\ic163501.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 6/9/2025 3:09:11 PM

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ Net-_U1-Pad16_ Net-_U1-Pad17_ Net-_U1-Pad18_ Net-_U1-Pad19_ Net-_U1-Pad20_ Net-_U1-Pad21_ Net-_U1-Pad22_ Net-_U1-Pad23_ Net-_U1-Pad24_ Net-_U1-Pad25_ Net-_U1-Pad26_ PORT
X1  Net-_U1-Pad7_ Net-_U1-Pad4_ Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad17_ Net-_U1-Pad3_ Net-_U1-Pad6_ Net-_U1-Pad5_ Registered_transceiver
X3  Net-_U1-Pad8_ Net-_U1-Pad4_ Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad18_ Net-_U1-Pad3_ Net-_U1-Pad6_ Net-_U1-Pad5_ Registered_transceiver
X4  Net-_U1-Pad9_ Net-_U1-Pad4_ Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad19_ Net-_U1-Pad3_ Net-_U1-Pad6_ Net-_U1-Pad5_ Registered_transceiver
X10  Net-_U1-Pad10_ Net-_U1-Pad4_ Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad20_ Net-_U1-Pad3_ Net-_U1-Pad6_ Net-_U1-Pad5_ Registered_transceiver
X5  Net-_U1-Pad11_ Net-_U1-Pad4_ Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad21_ Net-_U1-Pad3_ Net-_U1-Pad6_ Net-_U1-Pad5_ Registered_transceiver
X6  Net-_U1-Pad12_ Net-_U1-Pad4_ Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad22_ Net-_U1-Pad3_ Net-_U1-Pad6_ Net-_U1-Pad5_ Registered_transceiver
X7  Net-_U1-Pad13_ Net-_U1-Pad4_ Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad23_ Net-_U1-Pad3_ Net-_U1-Pad6_ Net-_U1-Pad5_ Registered_transceiver
X2  Net-_U1-Pad14_ Net-_U1-Pad4_ Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad24_ Net-_U1-Pad3_ Net-_U1-Pad6_ Net-_U1-Pad5_ Registered_transceiver
X8  Net-_U1-Pad15_ Net-_U1-Pad4_ Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad25_ Net-_U1-Pad3_ Net-_U1-Pad6_ Net-_U1-Pad5_ Registered_transceiver
X9  Net-_U1-Pad16_ Net-_U1-Pad4_ Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad26_ Net-_U1-Pad3_ Net-_U1-Pad6_ Net-_U1-Pad5_ Registered_transceiver

.end
