* C:\Users\chand\eSim\FOSSEE\eSim\library\SubcircuitLibrary\SN74S251\SN74S251.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 02/21/26 22:51:22

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
X1  Net-_U1-Pad4_ Net-_U3-Pad2_ Net-_U5-Pad2_ Net-_U4-Pad2_ Net-_U10-Pad2_ Net-_U9-Pad8_ 5_and
X2  Net-_U1-Pad3_ Net-_U6-Pad2_ Net-_U5-Pad2_ Net-_U4-Pad2_ Net-_U10-Pad2_ Net-_U9-Pad7_ 5_and
X3  Net-_U1-Pad2_ Net-_U3-Pad2_ Net-_U7-Pad2_ Net-_U4-Pad2_ Net-_U10-Pad2_ Net-_U9-Pad6_ 5_and
X4  Net-_U1-Pad1_ Net-_U6-Pad2_ Net-_U7-Pad2_ Net-_U4-Pad2_ Net-_U10-Pad2_ Net-_U9-Pad5_ 5_and
X5  Net-_U1-Pad15_ Net-_U3-Pad2_ Net-_U5-Pad2_ Net-_U8-Pad2_ Net-_U10-Pad2_ Net-_U9-Pad4_ 5_and
X6  Net-_U1-Pad14_ Net-_U6-Pad2_ Net-_U5-Pad2_ Net-_U8-Pad2_ Net-_U10-Pad2_ Net-_U9-Pad3_ 5_and
X7  Net-_U1-Pad13_ Net-_U3-Pad2_ Net-_U7-Pad2_ Net-_U8-Pad2_ Net-_U10-Pad2_ Net-_U9-Pad2_ 5_and
X8  Net-_U1-Pad12_ Net-_U6-Pad2_ Net-_U7-Pad2_ Net-_U8-Pad2_ Net-_U10-Pad2_ Net-_U9-Pad1_ 5_and
U2  Net-_U1-Pad7_ Net-_U10-Pad2_ d_inverter
U8  Net-_U4-Pad2_ Net-_U8-Pad2_ d_inverter
U4  Net-_U1-Pad9_ Net-_U4-Pad2_ d_inverter
U5  Net-_U1-Pad10_ Net-_U5-Pad2_ d_inverter
U7  Net-_U5-Pad2_ Net-_U7-Pad2_ d_inverter
U6  Net-_U3-Pad2_ Net-_U6-Pad2_ d_inverter
U3  Net-_U1-Pad11_ Net-_U3-Pad2_ d_inverter
U9  Net-_U9-Pad1_ Net-_U9-Pad2_ Net-_U9-Pad3_ Net-_U9-Pad4_ Net-_U9-Pad5_ Net-_U9-Pad6_ Net-_U9-Pad7_ Net-_U9-Pad8_ Net-_U10-Pad2_ Net-_U1-Pad6_ nor8_enable
U10  Net-_U1-Pad6_ Net-_U10-Pad2_ Net-_U10-Pad3_ one_input_tristate_buffer
U11  Net-_U10-Pad3_ Net-_U1-Pad5_ d_inverter
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ ? Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ ? PORT

.end
