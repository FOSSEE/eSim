* C:\FOSSEE\eSim\library\SubcircuitLibrary\SN74120\SN74120.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 05/24/25 11:09:50

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U2  /R_bar_1 Net-_U2-Pad2_ d_inverter
U3  Net-_U11-Pad3_ Net-_U3-Pad2_ d_inverter
U4  Net-_U4-Pad1_ Net-_U4-Pad2_ d_inverter
U5  /S1_bar_1 Net-_U5-Pad2_ d_inverter
U6  /S2_bar_1 Net-_U11-Pad2_ d_inverter
U7  /C_1 Net-_U7-Pad2_ d_inverter
U8  Net-_U2-Pad2_ Net-_U3-Pad2_ Net-_U4-Pad1_ d_or
U9  Net-_U4-Pad2_ Net-_U5-Pad2_ Net-_U11-Pad1_ d_or
U11  Net-_U11-Pad1_ Net-_U11-Pad2_ Net-_U11-Pad3_ d_or
U10  Net-_U10-Pad1_ /C_1 /Y_bar_1 d_nand
U12  Net-_U12-Pad1_ Net-_U12-Pad2_ d_inverter
U13  Net-_U12-Pad2_ Net-_U13-Pad2_ d_inverter
U16  /Y_bar_1 Net-_U16-Pad2_ d_inverter
U17  Net-_U17-Pad1_ Net-_U17-Pad2_ Net-_U15-Pad1_ d_or
U15  Net-_U15-Pad1_ Net-_U14-Pad2_ Net-_U10-Pad1_ d_or
U19  Net-_U16-Pad2_ Net-_U13-Pad2_ Net-_U19-Pad3_ d_or
U18  /Y_bar_1 /Y_1 d_inverter
X1  Net-_U7-Pad2_ Net-_U11-Pad3_ Net-_U12-Pad2_ Net-_U17-Pad1_ 3_and
X2  Net-_U11-Pad3_ Net-_U12-Pad2_ Net-_U10-Pad1_ Net-_U17-Pad2_ 3_and
X3  Net-_U11-Pad3_ /M_1 Net-_U19-Pad3_ Net-_U12-Pad1_ 3_and
U14  /Y_bar_1 Net-_U14-Pad2_ d_inverter
U20  /R_bar_2 Net-_U20-Pad2_ d_inverter
U21  Net-_U21-Pad1_ Net-_U21-Pad2_ d_inverter
U22  Net-_U22-Pad1_ Net-_U22-Pad2_ d_inverter
U23  /S1_bar_2 Net-_U23-Pad2_ d_inverter
U24  /S2_bar_2 Net-_U24-Pad2_ d_inverter
U25  /C_2 Net-_U25-Pad2_ d_inverter
U26  Net-_U20-Pad2_ Net-_U21-Pad2_ Net-_U22-Pad1_ d_or
U27  Net-_U22-Pad2_ Net-_U23-Pad2_ Net-_U27-Pad3_ d_or
U29  Net-_U27-Pad3_ Net-_U24-Pad2_ Net-_U21-Pad1_ d_or
U28  Net-_U28-Pad1_ /C_2 /Y_bar_2 d_nand
X4  Net-_U25-Pad2_ Net-_U21-Pad1_ Net-_U30-Pad2_ Net-_U35-Pad1_ 3_and
X5  Net-_U21-Pad1_ Net-_U30-Pad2_ Net-_U28-Pad1_ Net-_U35-Pad2_ 3_and
X6  Net-_U21-Pad1_ /M_2 Net-_U36-Pad3_ Net-_U30-Pad1_ 3_and
U30  Net-_U30-Pad1_ Net-_U30-Pad2_ d_inverter
U31  Net-_U30-Pad2_ Net-_U31-Pad2_ d_inverter
U34  /Y_bar_2 Net-_U34-Pad2_ d_inverter
U35  Net-_U35-Pad1_ Net-_U35-Pad2_ Net-_U33-Pad1_ d_or
U33  Net-_U33-Pad1_ Net-_U32-Pad2_ Net-_U28-Pad1_ d_or
U37  /Y_bar_2 /Y_2 d_inverter
U32  /Y_bar_2 Net-_U32-Pad2_ d_inverter
U36  Net-_U34-Pad2_ Net-_U31-Pad2_ Net-_U36-Pad3_ d_or
U1  /M_1 /S1_bar_1 /S2_bar_1 /R_bar_1 /C_1 /Y_1 /Y_bar_1 ? /Y_bar_2 /Y_2 /C_2 /R_bar_2 /S1_bar_2 /S2_bar_2 ? /M_2 PORT

.end
