* C:\Users\pt710\eSim-Workspace\7442\7442.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 03/24/25 00:31:00

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
X1  Net-_U1-Pad3_ Net-_U2-Pad3_ Net-_U3-Pad3_ Net-_U4-Pad3_ Net-_U11-Pad1_ 4_and
X2  Net-_U6-Pad3_ Net-_U2-Pad3_ Net-_U3-Pad3_ Net-_U4-Pad3_ Net-_U12-Pad1_ 4_and
X3  Net-_U1-Pad3_ Net-_U5-Pad3_ Net-_U3-Pad3_ Net-_U4-Pad3_ Net-_U13-Pad1_ 4_and
X4  Net-_U6-Pad3_ Net-_U5-Pad3_ Net-_U3-Pad3_ Net-_U4-Pad3_ Net-_U14-Pad1_ 4_and
X5  Net-_U1-Pad3_ Net-_U2-Pad3_ Net-_U7-Pad3_ Net-_U4-Pad3_ Net-_U15-Pad1_ 4_and
X6  Net-_U6-Pad3_ Net-_U2-Pad3_ Net-_U7-Pad3_ Net-_U4-Pad3_ Net-_U9-Pad1_ 4_and
X7  Net-_U1-Pad3_ Net-_U5-Pad3_ Net-_U7-Pad3_ Net-_U4-Pad3_ Net-_U10-Pad1_ 4_and
X8  Net-_U6-Pad3_ Net-_U5-Pad3_ Net-_U7-Pad3_ Net-_U4-Pad3_ Net-_U16-Pad1_ 4_and
X9  Net-_U1-Pad3_ Net-_U2-Pad3_ Net-_U3-Pad3_ Net-_U8-Pad3_ Net-_U17-Pad1_ 4_and
X10  Net-_U6-Pad3_ Net-_U2-Pad3_ Net-_U3-Pad3_ Net-_U8-Pad3_ Net-_U18-Pad1_ 4_and
U1  Net-_U1-Pad1_ Net-_U1-Pad1_ Net-_U1-Pad3_ d_nor
U6  Net-_U1-Pad3_ Net-_U1-Pad3_ Net-_U6-Pad3_ d_nor
U2  Net-_U2-Pad1_ Net-_U2-Pad1_ Net-_U2-Pad3_ d_nor
U5  Net-_U2-Pad3_ Net-_U2-Pad3_ Net-_U5-Pad3_ d_nor
U3  Net-_U3-Pad1_ Net-_U3-Pad1_ Net-_U3-Pad3_ d_nor
U7  Net-_U3-Pad3_ Net-_U3-Pad3_ Net-_U7-Pad3_ d_nor
U4  Net-_U4-Pad1_ Net-_U4-Pad1_ Net-_U4-Pad3_ d_nor
U8  Net-_U4-Pad3_ Net-_U4-Pad3_ Net-_U8-Pad3_ d_nor
U11  Net-_U11-Pad1_ Net-_U11-Pad1_ ? d_nor
U12  Net-_U12-Pad1_ Net-_U12-Pad1_ ? d_nor
U13  Net-_U13-Pad1_ Net-_U13-Pad1_ ? d_nor
U14  Net-_U14-Pad1_ Net-_U14-Pad1_ ? d_nor
U15  Net-_U15-Pad1_ Net-_U15-Pad1_ ? d_nor
U9  Net-_U9-Pad1_ Net-_U9-Pad1_ ? d_nor
U10  Net-_U10-Pad1_ Net-_U10-Pad1_ ? d_nor
U16  Net-_U16-Pad1_ Net-_U16-Pad1_ ? d_nor
U17  Net-_U17-Pad1_ Net-_U17-Pad1_ ? d_nor
U18  Net-_U18-Pad1_ Net-_U18-Pad1_ ? d_nor

.end
