* C:\FOSSEE\eSim\library\SubcircuitLibrary\MC1455B_ic1\MC1455B_ic1.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 07/14/24 18:24:09

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
Q2  Net-_Q1-Pad1_ Net-_Q1-Pad1_ Net-_Q2-Pad3_ eSim_PNP
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
Q4  Net-_Q1-Pad1_ Net-_Q1-Pad3_ Net-_Q4-Pad3_ eSim_NPN
Q6  Net-_Q16-Pad1_ Net-_Q1-Pad1_ Net-_Q6-Pad3_ eSim_PNP
Q8  GND Net-_Q10-Pad1_ Net-_Q6-Pad3_ eSim_PNP
Q7  Net-_Q10-Pad1_ Net-_Q7-Pad2_ Net-_Q4-Pad3_ eSim_NPN
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad1_ Net-_Q10-Pad3_ eSim_PNP
Q9  Net-_Q10-Pad1_ Net-_Q9-Pad2_ Net-_Q7-Pad2_ eSim_NPN
R3  Net-_Q18-Pad3_ Net-_Q6-Pad3_ 830
R4  Net-_Q18-Pad3_ Net-_Q10-Pad3_ 4.7k
R1  Net-_Q18-Pad3_ Net-_Q2-Pad3_ 4.7k
Q13  Net-_Q12-Pad3_ Net-_Q13-Pad2_ Net-_Q13-Pad3_ eSim_PNP
R6  Net-_Q18-Pad3_ Net-_Q13-Pad3_ 1k
R8  Net-_Q18-Pad3_ Net-_Q9-Pad2_ 5k
Q12  Net-_Q11-Pad1_ Net-_Q11-Pad3_ Net-_Q12-Pad3_ eSim_PNP
Q14  GND Net-_Q14-Pad2_ Net-_Q12-Pad3_ eSim_PNP
R2  Net-_Q4-Pad3_ GND 10k
Q11  Net-_Q11-Pad1_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_PNP
Q15  GND Net-_Q15-Pad2_ Net-_Q14-Pad2_ eSim_PNP
R5  Net-_Q11-Pad1_ GND 100k
R9  Net-_Q9-Pad2_ Net-_Q15-Pad2_ 5k
R10  Net-_Q15-Pad2_ GND 5k
Q16  Net-_Q16-Pad1_ Net-_Q11-Pad1_ GND eSim_NPN
Q17  Net-_D1-Pad2_ Net-_Q16-Pad1_ GND eSim_NPN
Q20  Net-_Q19-Pad1_ Net-_D1-Pad2_ GND eSim_NPN
R12  Net-_Q19-Pad1_ Net-_Q16-Pad1_ 4.7k
D1  Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
R11  Net-_D1-Pad1_ Net-_Q13-Pad2_ 7k
Q21  Net-_D2-Pad2_ Net-_Q19-Pad1_ Net-_Q21-Pad3_ eSim_NPN
R13  Net-_D2-Pad2_ Net-_Q18-Pad3_ 6.8k
Q22  Net-_Q18-Pad3_ Net-_D2-Pad2_ Net-_Q22-Pad3_ eSim_NPN
Q23  Net-_Q18-Pad3_ Net-_Q22-Pad3_ Net-_D2-Pad1_ eSim_NPN
R16  Net-_Q22-Pad3_ Net-_D2-Pad1_ 3.9k
D2  Net-_D2-Pad1_ Net-_D2-Pad2_ eSim_Diode
R15  Net-_Q21-Pad3_ Net-_Q24-Pad2_ 220
Q24  Net-_D2-Pad1_ Net-_Q24-Pad2_ GND eSim_NPN
R14  Net-_Q21-Pad3_ GND 4.7k
Q3  Net-_Q3-Pad1_ Net-_Q3-Pad2_ Net-_D1-Pad1_ eSim_PNP
Q5  Net-_Q5-Pad1_ Net-_Q3-Pad1_ GND eSim_NPN
R7  Net-_Q21-Pad3_ Net-_Q3-Pad1_ 100
Q18  Net-_Q13-Pad2_ Net-_Q13-Pad2_ Net-_Q18-Pad3_ eSim_PNP
Q19  Net-_Q19-Pad1_ Net-_Q13-Pad2_ Net-_Q18-Pad3_ eSim_PNP
U1  ? Net-_Q11-Pad2_ Net-_D2-Pad1_ Net-_Q3-Pad2_ Net-_Q9-Pad2_ Net-_Q1-Pad2_ Net-_Q5-Pad1_ Net-_Q18-Pad3_ PORT

.end
