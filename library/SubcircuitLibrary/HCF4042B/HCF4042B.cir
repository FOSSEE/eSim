* C:\FOSSEE\eSim\library\SubcircuitLibrary\HCF4042B\HCF4042B.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/20/25 11:33:35

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
M3  Net-_M1-Pad3_ Net-_M10-Pad2_ Net-_M1-Pad1_ VSS mosfet_n
M1  Net-_M1-Pad1_ Net-_M1-Pad2_ Net-_M1-Pad3_ VDD mosfet_p
M9  Net-_M1-Pad3_ Net-_M10-Pad2_ Net-_M11-Pad1_ VSS mosfet_n
M11  Net-_M11-Pad1_ Net-_M1-Pad2_ Net-_M1-Pad3_ VDD mosfet_p
U6  Net-_M1-Pad3_ Net-_U13-Pad1_ adc_bridge_1
U13  Net-_U13-Pad1_ Net-_U13-Pad2_ d_inverter
U29  Net-_U13-Pad2_ Net-_U29-Pad2_ d_inverter
U36  Net-_U29-Pad2_ Net-_U1-Pad2_ d_buffer
U19  Net-_U13-Pad2_ Net-_U19-Pad2_ d_inverter
U20  Net-_U19-Pad2_ Net-_U12-Pad2_ d_buffer
U12  Net-_M11-Pad1_ Net-_U12-Pad2_ adc_bridge_1
U32  Net-_U12-Pad2_ Net-_U1-Pad3_ d_inverter
U1  Net-_M1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_M2-Pad1_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_M4-Pad1_ Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_M7-Pad1_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ VDD VSS PORT
M5  Net-_M10-Pad1_ Net-_M10-Pad2_ Net-_M2-Pad1_ VSS mosfet_n
M2  Net-_M2-Pad1_ Net-_M1-Pad2_ Net-_M10-Pad1_ VDD mosfet_p
M10  Net-_M10-Pad1_ Net-_M10-Pad2_ Net-_M10-Pad3_ VSS mosfet_n
M13  Net-_M10-Pad3_ Net-_M1-Pad2_ Net-_M10-Pad1_ VDD mosfet_p
U7  Net-_M10-Pad1_ Net-_U16-Pad1_ adc_bridge_1
U16  Net-_U16-Pad1_ Net-_U16-Pad2_ d_inverter
U30  Net-_U16-Pad2_ Net-_U30-Pad2_ d_inverter
U39  Net-_U30-Pad2_ Net-_U1-Pad5_ d_buffer
U22  Net-_U16-Pad2_ Net-_U22-Pad2_ d_inverter
U23  Net-_U22-Pad2_ Net-_U14-Pad2_ d_buffer
U14  Net-_M10-Pad3_ Net-_U14-Pad2_ adc_bridge_1
U33  Net-_U14-Pad2_ Net-_U1-Pad6_ d_inverter
M6  Net-_M12-Pad1_ Net-_M10-Pad2_ Net-_M4-Pad1_ VSS mosfet_n
M4  Net-_M4-Pad1_ Net-_M1-Pad2_ Net-_M12-Pad1_ VDD mosfet_p
M12  Net-_M12-Pad1_ Net-_M10-Pad2_ Net-_M12-Pad3_ VSS mosfet_n
M14  Net-_M12-Pad3_ Net-_M1-Pad2_ Net-_M12-Pad1_ VDD mosfet_p
U8  Net-_M12-Pad1_ Net-_U17-Pad1_ adc_bridge_1
U17  Net-_U17-Pad1_ Net-_U17-Pad2_ d_inverter
U31  Net-_U17-Pad2_ Net-_U31-Pad2_ d_inverter
U40  Net-_U31-Pad2_ Net-_U1-Pad8_ d_buffer
U25  Net-_U17-Pad2_ Net-_U25-Pad2_ d_inverter
U26  Net-_U25-Pad2_ Net-_U15-Pad2_ d_buffer
U15  Net-_M12-Pad3_ Net-_U15-Pad2_ adc_bridge_1
U35  Net-_U15-Pad2_ Net-_U1-Pad9_ d_inverter
M8  Net-_M15-Pad1_ Net-_M10-Pad2_ Net-_M7-Pad1_ VSS mosfet_n
M7  Net-_M7-Pad1_ Net-_M1-Pad2_ Net-_M15-Pad1_ VDD mosfet_p
M15  Net-_M15-Pad1_ Net-_M10-Pad2_ Net-_M15-Pad3_ VSS mosfet_n
M16  Net-_M15-Pad3_ Net-_M1-Pad2_ Net-_M15-Pad1_ VDD mosfet_p
U9  Net-_M15-Pad1_ Net-_U21-Pad1_ adc_bridge_1
U21  Net-_U21-Pad1_ Net-_U21-Pad2_ d_inverter
U34  Net-_U21-Pad2_ Net-_U34-Pad2_ d_inverter
U42  Net-_U34-Pad2_ Net-_U1-Pad11_ d_buffer
U27  Net-_U21-Pad2_ Net-_U27-Pad2_ d_inverter
U28  Net-_U27-Pad2_ Net-_U18-Pad2_ d_buffer
U18  Net-_M15-Pad3_ Net-_U18-Pad2_ adc_bridge_1
U37  Net-_U18-Pad2_ Net-_U1-Pad12_ d_inverter
U4  Net-_U1-Pad13_ Net-_U10-Pad1_ d_inverter
M17  Net-_M17-Pad1_ Net-_M17-Pad2_ Net-_M17-Pad3_ VSS mosfet_n
M18  Net-_M17-Pad3_ Net-_M18-Pad2_ Net-_M17-Pad1_ VDD mosfet_p
M20  Net-_M17-Pad3_ Net-_M17-Pad2_ Net-_M19-Pad1_ VSS mosfet_n
M19  Net-_M19-Pad1_ Net-_M18-Pad2_ Net-_M17-Pad3_ VDD mosfet_p
U10  Net-_U10-Pad1_ Net-_M17-Pad1_ dac_bridge_1
U2  Net-_U1-Pad13_ Net-_M19-Pad1_ dac_bridge_1
U44  Net-_U43-Pad2_ Net-_U44-Pad2_ d_inverter
U43  Net-_U41-Pad2_ Net-_U43-Pad2_ d_inverter
U41  Net-_M17-Pad3_ Net-_U41-Pad2_ adc_bridge_1
U45  Net-_U44-Pad2_ Net-_M10-Pad2_ dac_bridge_1
U46  Net-_U43-Pad2_ Net-_M1-Pad2_ dac_bridge_1
U3  Net-_U1-Pad14_ Net-_U11-Pad1_ d_inverter
U11  Net-_U11-Pad1_ Net-_U11-Pad2_ d_inverter
U24  Net-_U11-Pad2_ Net-_U24-Pad2_ d_buffer
U38  Net-_U24-Pad2_ Net-_M17-Pad2_ dac_bridge_1
U5  Net-_U11-Pad1_ Net-_M18-Pad2_ dac_bridge_1

.end
