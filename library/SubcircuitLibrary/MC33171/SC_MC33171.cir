* C:\FOSSEE2\eSim\library\SubcircuitLibrary\SC_MC33171\SC_MC33171.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/07/25 00:42:32

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
Q1  Net-_I1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_PNP
Q3  Net-_Q3-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_PNP
Q6  Net-_Q6-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_PNP
Q9  Net-_Q11-Pad3_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_PNP
Q12  Net-_Q10-Pad3_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_PNP
Q14  Net-_D2-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_PNP
Q2  Net-_Q10-Pad1_ Net-_I1-Pad1_ Net-_Q1-Pad2_ eSim_PNP
Q4  Net-_Q10-Pad1_ Net-_Q4-Pad2_ Net-_Q3-Pad1_ eSim_PNP
Q5  Net-_D1-Pad1_ Net-_Q3-Pad1_ Net-_C1-Pad2_ eSim_PNP
Q8  Net-_C2-Pad2_ Net-_Q11-Pad3_ Net-_C1-Pad1_ eSim_PNP
Q11  Net-_Q10-Pad1_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_PNP
Q16  Net-_Q1-Pad3_ Net-_D2-Pad1_ Net-_C2-Pad1_ eSim_NPN
Q18  Net-_D2-Pad1_ Net-_C2-Pad1_ Net-_Q18-Pad3_ eSim_NPN
Q19  Net-_Q19-Pad1_ Net-_C2-Pad1_ Net-_I2-Pad1_ eSim_NPN
Q17  Net-_C2-Pad1_ Net-_Q13-Pad3_ Net-_Q10-Pad1_ eSim_NPN
Q15  Net-_D2-Pad2_ ? Net-_Q10-Pad1_ eSim_NPN
Q13  Net-_D2-Pad1_ Net-_Q10-Pad3_ Net-_Q13-Pad3_ eSim_NPN
Q7  Net-_C2-Pad2_ Net-_D1-Pad1_ Net-_Q7-Pad3_ eSim_NPN
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 0.8p
R1  Net-_Q6-Pad1_ Net-_C1-Pad2_ 10k
R3  Net-_Q6-Pad1_ Net-_C1-Pad1_ 10k
D1  Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
R2  Net-_D1-Pad2_ Net-_Q10-Pad1_ 10k
R4  Net-_Q7-Pad3_ Net-_Q10-Pad1_ 10k
D2  Net-_D2-Pad1_ Net-_D2-Pad2_ eSim_Diode
R6  Net-_D2-Pad2_ Net-_C2-Pad1_ 10k
R7  Net-_C2-Pad1_ Net-_Q18-Pad3_ 10k
D3  Net-_C2-Pad1_ Net-_D2-Pad2_ eSim_Diode
R8  Net-_Q19-Pad1_ Net-_Q18-Pad3_ 10k
C2  Net-_C2-Pad1_ Net-_C2-Pad2_ 100u
Q10  Net-_Q10-Pad1_ Net-_C2-Pad2_ Net-_Q10-Pad3_ eSim_PNP
R5  Net-_Q13-Pad3_ Net-_Q10-Pad1_ 10k
U1  Net-_D1-Pad2_ Net-_Q4-Pad2_ Net-_Q11-Pad2_ Net-_Q10-Pad1_ Net-_Q7-Pad3_ Net-_Q18-Pad3_ Net-_Q1-Pad3_ ? PORT
I1  Net-_I1-Pad1_ GND dc
I2  Net-_I2-Pad1_ GND dc

.end
