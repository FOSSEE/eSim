* C:\FOSSEE\eSim\library\SubcircuitLibrary\LM323A_sub\LM323A_sub.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 20/06/2024 4:29:20 PM

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U1  Net-_C2-Pad2_ Net-_J1-Pad3_ zener
U2  Net-_C2-Pad2_ Net-_Q1-Pad3_ zener
J1  Net-_J1-Pad1_ Net-_C2-Pad2_ Net-_J1-Pad3_ jfet_n
Q4  Net-_C2-Pad1_ Net-_Q4-Pad2_ Net-_C2-Pad2_ eSim_NPN
R5  Net-_C2-Pad2_ Net-_Q4-Pad2_ 6k
R4  Net-_Q4-Pad2_ Net-_Q5-Pad1_ 2k
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad1_ Net-_C2-Pad2_ eSim_NPN
Q9  Net-_Q13-Pad2_ Net-_Q13-Pad2_ Net-_Q10-Pad1_ eSim_NPN
R9  Net-_Q13-Pad2_ Net-_R10-Pad1_ 3.9k
R8  Net-_R10-Pad1_ Net-_Q5-Pad2_ 2.6k
Q5  Net-_Q5-Pad1_ Net-_Q5-Pad2_ Net-_Q5-Pad3_ eSim_PNP
R7  Net-_Q5-Pad2_ Net-_Q5-Pad3_ 520
Q8  Net-_Q11-Pad3_ Net-_Q1-Pad3_ Net-_Q5-Pad3_ eSim_NPN
Q1  Net-_Q1-Pad1_ Net-_J1-Pad3_ Net-_Q1-Pad3_ eSim_NPN
R10  Net-_R10-Pad1_ Net-_Q12-Pad2_ 6k
R11  Net-_C2-Pad2_ Net-_Q13-Pad3_ 2.8k
Q12  Net-_Q12-Pad1_ Net-_Q12-Pad2_ Net-_Q12-Pad3_ eSim_NPN
Q14  Net-_C1-Pad1_ Net-_C1-Pad2_ Net-_Q12-Pad3_ eSim_NPN
Q13  Net-_Q12-Pad3_ Net-_Q13-Pad2_ Net-_Q13-Pad3_ eSim_NPN
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 40pF
Q15  Net-_C2-Pad2_ Net-_C1-Pad1_ Net-_Q15-Pad3_ eSim_PNP
Q16  Net-_C2-Pad2_ Net-_Q15-Pad3_ Net-_Q16-Pad3_ eSim_PNP
R13  Net-_C1-Pad1_ Net-_Q15-Pad3_ 5.6k
R12  Net-_Q15-Pad3_ Net-_Q16-Pad3_ 3k
R14  Net-_Q16-Pad3_ Net-_C2-Pad1_ 1k
Q2  Net-_Q2-Pad1_ Net-_Q11-Pad2_ Net-_Q1-Pad3_ eSim_NPN
R3  Net-_Q1-Pad3_ Net-_Q2-Pad1_ 10k
R2  Net-_Q2-Pad1_ Net-_Q11-Pad2_ 300
Q7  Net-_Q1-Pad1_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_NPN
Q11  Net-_Q11-Pad1_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_NPN
C2  Net-_C2-Pad1_ Net-_C2-Pad2_ 10pF
Q6  Net-_Q1-Pad1_ Net-_Q1-Pad1_ Net-_Q6-Pad3_ eSim_PNP
Q3  Net-_Q11-Pad2_ Net-_Q1-Pad1_ Net-_Q3-Pad3_ eSim_PNP
R1  Net-_Q3-Pad3_ Net-_J1-Pad1_ 1k
R6  Net-_Q6-Pad3_ Net-_J1-Pad1_ 1k
Q18  Net-_C2-Pad1_ Net-_Q18-Pad2_ Net-_Q18-Pad3_ eSim_NPN
Q17  Net-_C2-Pad1_ Net-_Q11-Pad1_ Net-_J1-Pad1_ eSim_PNP
R18  Net-_Q18-Pad2_ Net-_Q22-Pad3_ 300
R15  Net-_C1-Pad2_ Net-_R15-Pad2_ 4k
R16  Net-_R16-Pad1_ Net-_Q18-Pad3_ 50
R22  Net-_R16-Pad1_ Net-_Q12-Pad1_ 2k
U3  Net-_R17-Pad2_ Net-_J1-Pad1_ zener
R17  Net-_Q18-Pad2_ Net-_R17-Pad2_ 16k
R19  Net-_Q11-Pad1_ Net-_Q19-Pad2_ 210
Q19  Net-_Q11-Pad1_ Net-_Q19-Pad2_ Net-_J1-Pad1_ eSim_PNP
Q20  Net-_Q11-Pad1_ Net-_C2-Pad1_ Net-_Q20-Pad3_ eSim_NPN
R20  Net-_C2-Pad1_ Net-_Q21-Pad2_ 100
R21  Net-_Q20-Pad3_ Net-_Q12-Pad1_ 200
Q21  Net-_J1-Pad1_ Net-_Q21-Pad2_ Net-_Q12-Pad1_ eSim_NPN
R24  Net-_R16-Pad1_ Net-_Q23-Pad3_ 0.12
Q23  Net-_J1-Pad1_ Net-_Q12-Pad1_ Net-_Q23-Pad3_ eSim_NPN
R25  Net-_R15-Pad2_ Net-_R16-Pad1_ 900
R26  Net-_C2-Pad2_ Net-_R15-Pad2_ 1.7k
Q22  Net-_J1-Pad1_ Net-_Q12-Pad1_ Net-_Q22-Pad3_ eSim_NPN
R23  Net-_R16-Pad1_ Net-_Q22-Pad3_ 13
U4  Net-_J1-Pad1_ Net-_C2-Pad2_ Net-_R16-Pad1_ PORT

.end
