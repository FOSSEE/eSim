.title KiCad schematic
Q35 Net-_C2-Pad2_ Net-_Q31-Pad1_ Net-_Q33-Pad3_ eSim_PNP
R20 Net-_Q30-Pad1_ Net-_R19-Pad1_ 19.5k
Q30 Net-_Q30-Pad1_ Net-_Q30-Pad1_ Net-_Q11-Pad3_ eSim_NPN
Q31 Net-_Q31-Pad1_ Net-_Q30-Pad1_ Net-_Q31-Pad3_ eSim_NPN
Q34 Net-_C2-Pad2_ Net-_Q34-Pad2_ Net-_Q34-Pad3_ eSim_NPN
R22 Net-_Q11-Pad3_ Net-_Q34-Pad3_ 1k
R23 Net-_Q11-Pad3_ Net-_Q34-Pad2_ 50k
Q37 Net-_Q12-Pad3_ Net-_Q37-Pad2_ Net-_Q34-Pad2_ eSim_NPN
Q39 Net-_Q37-Pad2_ Net-_Q34-Pad2_ Net-_Q39-Pad3_ eSim_NPN
R21 Net-_Q11-Pad3_ Net-_Q31-Pad3_ 5k
R24 Net-_Q11-Pad3_ Net-_Q39-Pad3_ 1k
R15 Net-_Q11-Pad3_ Net-_Q26-Pad3_ 50
Q28 Net-_C2-Pad2_ Net-_Q26-Pad3_ Net-_Q11-Pad3_ eSim_NPN
R18 Net-_Q11-Pad3_ Net-_Q26-Pad2_ 50k
U1 Net-_D3-Pad1_ Net-_Q33-Pad2_ Net-_Q40-Pad2_ Net-_Q11-Pad3_ Net-_Q1-Pad2_ Net-_Q8-Pad2_ Net-_D2-Pad1_ Net-_Q12-Pad3_ PORT
Q26 Net-_D4-Pad2_ Net-_Q26-Pad2_ Net-_Q26-Pad3_ eSim_NPN
Q22 Net-_Q11-Pad3_ Net-_D4-Pad2_ Net-_Q22-Pad3_ eSim_PNP
R14 Net-_Q22-Pad3_ Net-_D3-Pad1_ 50
D4 Net-_D3-Pad2_ Net-_D4-Pad2_ eSim_Diode
D3 Net-_D3-Pad1_ Net-_D3-Pad2_ eSim_Diode
Q21 Net-_Q12-Pad3_ Net-_C2-Pad1_ Net-_Q21-Pad3_ eSim_NPN
R13 Net-_D3-Pad1_ Net-_Q21-Pad3_ 25
Q24 Net-_C2-Pad1_ Net-_Q24-Pad2_ Net-_Q12-Pad3_ eSim_PNP
Q23 Net-_C2-Pad1_ Net-_Q21-Pad3_ Net-_D3-Pad1_ eSim_NPN
Q25 Net-_C2-Pad1_ Net-_Q25-Pad2_ Net-_D4-Pad2_ eSim_NPN
Q27 Net-_D4-Pad2_ Net-_C2-Pad2_ Net-_Q26-Pad2_ eSim_NPN
R17 Net-_Q25-Pad2_ Net-_D4-Pad2_ 7.5k
R16 Net-_Q25-Pad2_ Net-_C2-Pad1_ 4.5k
C2 Net-_C2-Pad1_ Net-_C2-Pad2_ 30p
Q32 Net-_Q31-Pad1_ Net-_Q32-Pad2_ Net-_Q12-Pad3_ eSim_PNP
R19 Net-_R19-Pad1_ Net-_Q24-Pad2_ 19.5k
Q33 Net-_Q32-Pad2_ Net-_Q33-Pad2_ Net-_Q33-Pad3_ eSim_NPN
Q29 Net-_Q24-Pad2_ Net-_Q24-Pad2_ Net-_Q12-Pad3_ eSim_PNP
Q36 Net-_Q32-Pad2_ Net-_Q32-Pad2_ Net-_Q12-Pad3_ eSim_PNP
Q40 Net-_Q32-Pad2_ Net-_Q40-Pad2_ Net-_Q38-Pad3_ eSim_NPN
Q38 Net-_Q37-Pad2_ Net-_Q31-Pad1_ Net-_Q38-Pad3_ eSim_PNP
Q15 Net-_C1-Pad1_ Net-_Q12-Pad1_ Net-_Q12-Pad3_ eSim_PNP
Q18 Net-_C1-Pad1_ Net-_Q18-Pad2_ Net-_D2-Pad1_ eSim_NPN
Q16 Net-_C1-Pad1_ Net-_Q16-Pad2_ Net-_D1-Pad2_ eSim_NPN
Q19 Net-_Q12-Pad3_ Net-_C1-Pad1_ Net-_Q18-Pad2_ eSim_NPN
R11 Net-_D2-Pad1_ Net-_Q18-Pad2_ 25
R9 Net-_Q16-Pad2_ Net-_D1-Pad2_ 7.5k
R8 Net-_Q16-Pad2_ Net-_C1-Pad1_ 4.5k
Q12 Net-_Q12-Pad1_ Net-_Q12-Pad1_ Net-_Q12-Pad3_ eSim_PNP
Q9 Net-_Q10-Pad1_ Net-_Q1-Pad1_ Net-_Q12-Pad3_ eSim_PNP
C1 Net-_C1-Pad1_ Net-_C1-Pad2_ 30p
R6 Net-_Q10-Pad2_ Net-_R5-Pad1_ 19.5k
R5 Net-_R5-Pad1_ Net-_Q12-Pad1_ 19.5k
Q14 Net-_D1-Pad2_ Net-_C1-Pad2_ Net-_Q14-Pad3_ eSim_NPN
Q17 Net-_D1-Pad2_ Net-_Q14-Pad3_ Net-_Q13-Pad2_ eSim_NPN
R10 Net-_Q11-Pad3_ Net-_Q13-Pad2_ 50
R7 Net-_Q11-Pad3_ Net-_Q14-Pad3_ 50k
Q13 Net-_C1-Pad2_ Net-_Q13-Pad2_ Net-_Q11-Pad3_ eSim_NPN
Q5 Net-_Q1-Pad1_ Net-_Q1-Pad1_ Net-_Q12-Pad3_ eSim_PNP
Q6 Net-_C1-Pad2_ Net-_Q10-Pad1_ Net-_Q6-Pad3_ eSim_PNP
Q8 Net-_Q1-Pad1_ Net-_Q8-Pad2_ Net-_Q6-Pad3_ eSim_NPN
Q3 Net-_Q2-Pad1_ Net-_Q10-Pad1_ Net-_Q1-Pad3_ eSim_PNP
Q1 Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
R1 Net-_Q11-Pad3_ Net-_Q2-Pad3_ 1k
Q4 Net-_Q12-Pad3_ Net-_Q2-Pad1_ Net-_Q2-Pad2_ eSim_NPN
Q2 Net-_Q2-Pad1_ Net-_Q2-Pad2_ Net-_Q2-Pad3_ eSim_NPN
D1 Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
Q20 Net-_Q11-Pad3_ Net-_D1-Pad2_ Net-_Q20-Pad3_ eSim_PNP
D2 Net-_D2-Pad1_ Net-_D1-Pad1_ eSim_Diode
R12 Net-_Q20-Pad3_ Net-_D2-Pad1_ 50
Q7 Net-_C1-Pad2_ Net-_Q2-Pad2_ Net-_Q7-Pad3_ eSim_NPN
R4 Net-_Q11-Pad3_ Net-_Q10-Pad3_ 5k
R2 Net-_Q11-Pad3_ Net-_Q2-Pad2_ 50k
R3 Net-_Q11-Pad3_ Net-_Q7-Pad3_ 1k
Q10 Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
Q11 Net-_Q10-Pad2_ Net-_Q10-Pad2_ Net-_Q11-Pad3_ eSim_NPN
.end
