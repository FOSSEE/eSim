* C:\Users\senba\Desktop\FOSSEE\eSim\library\SubcircuitLibrary\SN74LS42\SN74LS42.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 05/17/25 19:43:54

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U5  Net-_U2-Pad4_ Net-_U5-Pad2_ d_inverter
U9  Net-_U2-Pad7_ Net-_U10-Pad1_ d_inverter
U12  Net-_U12-Pad1_ Net-_U12-Pad2_ d_inverter
U15  Net-_U15-Pad1_ Net-_U15-Pad2_ d_inverter
U6  Net-_U5-Pad2_ Net-_U6-Pad2_ d_inverter
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ d_inverter
U13  Net-_U12-Pad2_ Net-_U13-Pad2_ d_inverter
U16  Net-_U15-Pad2_ Net-_U16-Pad2_ d_inverter
X3  Net-_U15-Pad2_ Net-_U12-Pad2_ Net-_U5-Pad2_ Net-_U10-Pad2_ Net-_U4-Pad1_ 4_and
X2  Net-_U10-Pad1_ Net-_U12-Pad2_ Net-_U15-Pad2_ Net-_U6-Pad2_ Net-_U3-Pad1_ 4_and
X4  Net-_U15-Pad2_ Net-_U10-Pad2_ Net-_U12-Pad2_ Net-_U6-Pad2_ Net-_U7-Pad1_ 4_and
X5  Net-_U15-Pad2_ Net-_U10-Pad1_ Net-_U13-Pad2_ Net-_U5-Pad2_ Net-_U8-Pad1_ 4_and
X6  Net-_U15-Pad2_ Net-_U10-Pad1_ Net-_U6-Pad2_ Net-_U13-Pad2_ Net-_U11-Pad1_ 4_and
X7  Net-_U15-Pad2_ Net-_U5-Pad2_ Net-_U10-Pad2_ Net-_U13-Pad2_ Net-_U14-Pad1_ 4_and
X8  Net-_U6-Pad2_ Net-_U10-Pad2_ Net-_U13-Pad2_ Net-_U15-Pad2_ Net-_U17-Pad1_ 4_and
X9  Net-_U5-Pad2_ Net-_U10-Pad1_ Net-_U12-Pad2_ Net-_U16-Pad2_ Net-_U18-Pad1_ 4_and
X10  Net-_U6-Pad2_ Net-_U10-Pad1_ Net-_U12-Pad2_ Net-_U16-Pad2_ Net-_U19-Pad1_ 4_and
X1  Net-_U5-Pad2_ Net-_U10-Pad1_ Net-_U12-Pad2_ Net-_U15-Pad2_ Net-_U1-Pad1_ 4_and
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ d_inverter
U3  Net-_U3-Pad1_ Net-_U2-Pad2_ d_inverter
U4  Net-_U4-Pad1_ Net-_U2-Pad3_ d_inverter
U7  Net-_U7-Pad1_ Net-_U2-Pad5_ d_inverter
U8  Net-_U8-Pad1_ Net-_U2-Pad6_ d_inverter
U11  Net-_U11-Pad1_ Net-_U11-Pad2_ d_inverter
U14  Net-_U14-Pad1_ Net-_U14-Pad2_ d_inverter
U17  Net-_U17-Pad1_ Net-_U17-Pad2_ d_inverter
U18  Net-_U18-Pad1_ Net-_U18-Pad2_ d_inverter
U19  Net-_U19-Pad1_ Net-_U19-Pad2_ d_inverter
U2  Net-_U1-Pad2_ Net-_U2-Pad2_ Net-_U2-Pad3_ Net-_U2-Pad4_ Net-_U2-Pad5_ Net-_U2-Pad6_ Net-_U2-Pad7_ Net-_U11-Pad2_ Net-_U12-Pad1_ Net-_U14-Pad2_ Net-_U15-Pad1_ Net-_U17-Pad2_ Net-_U18-Pad2_ Net-_U19-Pad2_ PORT

.end
