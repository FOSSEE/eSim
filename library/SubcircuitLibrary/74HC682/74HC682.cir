* C:\Users\senba\Desktop\FOSSEE\eSim\library\SubcircuitLibrary\74HC682\74HC682.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 11/08/25 15:10:39

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
X1  Net-_U10-Pad3_ Net-_U11-Pad3_ Net-_U12-Pad3_ Net-_X1-Pad4_ 3_and
X2  Net-_U13-Pad3_ Net-_U14-Pad3_ Net-_U15-Pad3_ Net-_X15-Pad2_ 3_and
X3  Net-_U11-Pad3_ Net-_U12-Pad3_ Net-_U13-Pad3_ Net-_X16-Pad1_ 3_and
X4  Net-_U15-Pad3_ Net-_U16-Pad3_ Net-_U17-Pad3_ Net-_X16-Pad2_ 3_and
X5  Net-_U1-Pad1_ Net-_U17-Pad3_ Net-_U2-Pad2_ Net-_X16-Pad3_ 3_and
X6  Net-_U14-Pad3_ Net-_U13-Pad3_ Net-_U12-Pad3_ Net-_X17-Pad1_ 3_and
X7  Net-_U17-Pad3_ Net-_U16-Pad3_ Net-_U15-Pad3_ Net-_X17-Pad2_ 3_and
X8  Net-_U1-Pad5_ Net-_U17-Pad3_ Net-_U4-Pad2_ Net-_U22-Pad2_ 3_and
X9  Net-_U16-Pad3_ Net-_U15-Pad3_ Net-_U14-Pad3_ Net-_U23-Pad1_ 3_and
X10  Net-_U1-Pad7_ Net-_U17-Pad3_ Net-_U5-Pad2_ Net-_U23-Pad2_ 3_and
X11  Net-_U17-Pad3_ Net-_U16-Pad3_ Net-_U15-Pad3_ Net-_U24-Pad1_ 3_and
U18  Net-_U16-Pad3_ Net-_U17-Pad3_ Net-_U18-Pad3_ d_and
U19  Net-_U1-Pad3_ Net-_U19-Pad2_ Net-_U19-Pad3_ d_and
U20  Net-_U1-Pad9_ Net-_U20-Pad2_ Net-_U20-Pad3_ d_and
X14  Net-_U1-Pad11_ Net-_U17-Pad3_ Net-_U16-Pad3_ Net-_U7-Pad2_ Net-_X14-Pad5_ 4_and
X12  Net-_U1-Pad13_ Net-_U17-Pad3_ Net-_U8-Pad2_ Net-_X12-Pad4_ 3_and
U10  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U10-Pad3_ d_xnor
U11  Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U11-Pad3_ d_xnor
U12  Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U12-Pad3_ d_xnor
U13  Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U13-Pad3_ d_xnor
U14  Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U14-Pad3_ d_xnor
U15  Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U15-Pad3_ d_xnor
U16  Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U16-Pad3_ d_xnor
U17  Net-_U1-Pad15_ Net-_U1-Pad16_ Net-_U17-Pad3_ d_xnor
U2  Net-_U1-Pad2_ Net-_U2-Pad2_ d_inverter
U3  Net-_U1-Pad4_ Net-_U19-Pad2_ d_inverter
U4  Net-_U1-Pad6_ Net-_U4-Pad2_ d_inverter
U5  Net-_U1-Pad8_ Net-_U5-Pad2_ d_inverter
U6  Net-_U1-Pad10_ Net-_U20-Pad2_ d_inverter
U7  Net-_U1-Pad12_ Net-_U7-Pad2_ d_inverter
U8  Net-_U1-Pad14_ Net-_U8-Pad2_ d_inverter
U9  Net-_U1-Pad16_ Net-_U21-Pad2_ d_inverter
X13  Net-_U16-Pad3_ Net-_U15-Pad3_ Net-_U14-Pad3_ Net-_U13-Pad3_ Net-_U22-Pad1_ 4_and
X15  Net-_X1-Pad4_ Net-_X15-Pad2_ Net-_U18-Pad3_ Net-_U25-Pad1_ 3_and
X16  Net-_X16-Pad1_ Net-_X16-Pad2_ Net-_X16-Pad3_ Net-_X16-Pad4_ 3_and
X17  Net-_X17-Pad1_ Net-_X17-Pad2_ Net-_U19-Pad3_ Net-_X17-Pad4_ 3_and
U25  Net-_U25-Pad1_ Net-_U1-Pad17_ d_inverter
U22  Net-_U22-Pad1_ Net-_U22-Pad2_ Net-_U22-Pad3_ d_and
U23  Net-_U23-Pad1_ Net-_U23-Pad2_ Net-_U23-Pad3_ d_and
X18  Net-_X16-Pad4_ Net-_X17-Pad4_ Net-_U22-Pad3_ Net-_U23-Pad3_ Net-_U26-Pad1_ 4_OR
U24  Net-_U24-Pad1_ Net-_U20-Pad3_ Net-_U24-Pad3_ d_and
U21  Net-_U1-Pad15_ Net-_U21-Pad2_ Net-_U21-Pad3_ d_and
X19  Net-_U24-Pad3_ Net-_X14-Pad5_ Net-_X12-Pad4_ Net-_U21-Pad3_ Net-_U26-Pad2_ 4_OR
U26  Net-_U26-Pad1_ Net-_U26-Pad2_ Net-_U1-Pad18_ d_nor
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ Net-_U1-Pad16_ Net-_U1-Pad17_ Net-_U1-Pad18_ PORT

.end
