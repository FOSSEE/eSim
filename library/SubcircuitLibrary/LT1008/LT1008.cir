.title KiCad schematic
R10 Net-_Q21-Pad3_ Net-_J1-Pad1_ 4.2k
R9 Net-_Q20-Pad3_ Net-_Q19-Pad3_ 1.5k
R6 Net-_Q1-Pad1_ Net-_Q19-Pad3_ 50k
Q19 Net-_Q10-Pad3_ Net-_Q10-Pad3_ Net-_Q19-Pad3_ eSim_NPN
Q22 Net-_Q21-Pad1_ Net-_Q22-Pad2_ Net-_Q22-Pad3_ eSim_NPN
Q29 Net-_Q16-Pad2_ Net-_J1-Pad3_ Net-_Q29-Pad3_ eSim_NPN
Q23 Net-_J1-Pad3_ Net-_J1-Pad3_ Net-_Q14-Pad2_ eSim_NPN
Q20 Net-_J1-Pad2_ Net-_Q12-Pad1_ Net-_Q20-Pad3_ eSim_PNP
J1 Net-_J1-Pad1_ Net-_J1-Pad2_ Net-_J1-Pad3_ jfet_n
Q27 Net-_Q16-Pad2_ Net-_J1-Pad3_ Net-_Q24-Pad2_ eSim_NPN
U1 Net-_Q25-Pad2_ Net-_Q1-Pad3_ Net-_Q1-Pad2_ Net-_J1-Pad2_ unconnected-_U1-Pad5_ Net-_Q40-Pad3_ Net-_J1-Pad1_ Net-_R13-Pad2_ PORT
R22 Net-_Q41-Pad2_ Net-_Q40-Pad3_ 70
Q34 Net-_Q33-Pad2_ Net-_Q16-Pad2_ Net-_J1-Pad1_ eSim_PNP
Q35 Net-_Q35-Pad1_ Net-_Q33-Pad2_ Net-_Q35-Pad3_ eSim_NPN
R17 Net-_Q35-Pad1_ Net-_Q33-Pad2_ 1.5k
R19 Net-_Q38-Pad3_ Net-_Q40-Pad3_ 3k
Q40 Net-_Q35-Pad1_ Net-_Q40-Pad2_ Net-_Q40-Pad3_ eSim_NPN
Q42 Net-_J1-Pad1_ Net-_Q35-Pad1_ Net-_Q40-Pad2_ eSim_NPN
R21 Net-_Q40-Pad3_ Net-_Q40-Pad2_ 60
Q38 Net-_Q37-Pad2_ Net-_Q22-Pad3_ Net-_Q38-Pad3_ eSim_PNP
Q36 Net-_J1-Pad2_ Net-_Q22-Pad3_ Net-_Q35-Pad3_ eSim_PNP
R18 Net-_J1-Pad2_ Net-_Q37-Pad3_ 40
Q32 Net-_Q22-Pad3_ Net-_Q32-Pad2_ Net-_Q32-Pad3_ eSim_NPN
R16 Net-_J1-Pad2_ Net-_Q32-Pad3_ 320
Q37 Net-_Q22-Pad3_ Net-_Q37-Pad2_ Net-_Q37-Pad3_ eSim_NPN
Q41 Net-_Q22-Pad3_ Net-_Q41-Pad2_ Net-_Q40-Pad3_ eSim_PNP
Q43 Net-_J1-Pad2_ Net-_Q22-Pad3_ Net-_Q41-Pad2_ eSim_PNP
Q39 Net-_Q37-Pad2_ Net-_Q37-Pad2_ Net-_Q39-Pad3_ eSim_NPN
R20 Net-_J1-Pad2_ Net-_Q39-Pad3_ 330
R15 Net-_Q32-Pad2_ Net-_Q14-Pad2_ 20k
Q28 Net-_Q24-Pad2_ Net-_Q14-Pad2_ Net-_Q28-Pad3_ eSim_NPN
R14 Net-_J1-Pad2_ Net-_Q29-Pad3_ 16k
R12 Net-_J1-Pad2_ Net-_Q28-Pad3_ 3.3k
Q24 Net-_Q14-Pad2_ Net-_Q24-Pad2_ Net-_J1-Pad2_ eSim_NPN
Q21 Net-_Q21-Pad1_ Net-_Q21-Pad2_ Net-_Q21-Pad3_ eSim_PNP
Q25 Net-_Q25-Pad1_ Net-_Q25-Pad2_ Net-_Q21-Pad3_ eSim_PNP
R13 Net-_Q25-Pad1_ Net-_R13-Pad2_ 3k
Q33 Net-_J1-Pad1_ Net-_Q33-Pad2_ Net-_Q31-Pad1_ eSim_NPN
Q30 Net-_Q16-Pad2_ Net-_Q16-Pad2_ Net-_J1-Pad1_ eSim_PNP
Q31 Net-_Q31-Pad1_ Net-_Q25-Pad1_ Net-_Q22-Pad3_ eSim_NPN
Q26 Net-_Q25-Pad1_ Net-_Q21-Pad1_ Net-_Q22-Pad3_ eSim_NPN
R11 Net-_Q22-Pad2_ Net-_Q21-Pad1_ 3k
Q4 Net-_Q21-Pad2_ Net-_Q21-Pad2_ Net-_Q4-Pad3_ eSim_PNP
Q5 Net-_Q21-Pad2_ Net-_Q10-Pad3_ Net-_Q3-Pad1_ eSim_NPN
Q13 Net-_Q11-Pad3_ Net-_Q13-Pad2_ Net-_Q12-Pad1_ eSim_NPN
Q6 Net-_Q25-Pad2_ Net-_Q10-Pad3_ Net-_Q6-Pad3_ eSim_NPN
Q44 Net-_Q1-Pad3_ Net-_Q11-Pad1_ Net-_Q11-Pad3_ eSim_PNP
Q45 Net-_Q1-Pad2_ Net-_Q11-Pad1_ Net-_Q11-Pad3_ eSim_PNP
Q49 Net-_Q11-Pad3_ Net-_Q10-Pad1_ Net-_Q10-Pad3_ eSim_PNP
Q10 Net-_Q10-Pad1_ Net-_Q10-Pad1_ Net-_Q10-Pad3_ eSim_PNP
R1 Net-_Q4-Pad3_ Net-_J1-Pad1_ 22k
Q15 Net-_Q11-Pad1_ Net-_Q14-Pad2_ Net-_Q15-Pad3_ eSim_NPN
Q14 Net-_Q10-Pad1_ Net-_Q14-Pad2_ Net-_Q14-Pad3_ eSim_NPN
R4 Net-_R4-Pad1_ Net-_Q14-Pad3_ 3.3k
R7 Net-_R4-Pad1_ Net-_Q15-Pad3_ 3.3k
R3 Net-_J1-Pad2_ Net-_Q9-Pad3_ 4.3k
Q9 Net-_Q12-Pad1_ Net-_Q14-Pad2_ Net-_Q9-Pad3_ eSim_NPN
R5 Net-_J1-Pad2_ Net-_R4-Pad1_ 4.8k
Q16 Net-_Q10-Pad3_ Net-_Q16-Pad2_ Net-_Q16-Pad3_ eSim_PNP
R8 Net-_Q16-Pad3_ Net-_J1-Pad1_ 1.3k
Q18 Net-_Q10-Pad3_ Net-_Q10-Pad3_ Net-_Q17-Pad2_ eSim_NPN
Q17 Net-_Q10-Pad3_ Net-_Q17-Pad2_ Net-_Q11-Pad1_ eSim_NPN
Q7 Net-_Q25-Pad2_ Net-_Q25-Pad2_ Net-_Q7-Pad3_ eSim_PNP
R2 Net-_Q7-Pad3_ Net-_J1-Pad1_ 22k
Q8 Net-_Q6-Pad3_ Net-_Q1-Pad2_ Net-_Q12-Pad1_ eSim_NPN
Q3 Net-_Q3-Pad1_ Net-_Q1-Pad3_ Net-_Q12-Pad1_ eSim_NPN
Q46 Net-_Q12-Pad1_ Net-_Q12-Pad1_ Net-_Q1-Pad2_ eSim_NPN
Q2 Net-_Q1-Pad1_ Net-_Q1-Pad3_ Net-_Q1-Pad2_ eSim_NPN
Q1 Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
Q12 Net-_Q12-Pad1_ Net-_Q12-Pad1_ Net-_Q1-Pad3_ eSim_NPN
Q48 Net-_Q12-Pad1_ Net-_Q12-Pad1_ Net-_Q13-Pad2_ eSim_NPN
Q47 Net-_Q13-Pad2_ Net-_Q11-Pad1_ Net-_Q11-Pad3_ eSim_PNP
Q11 Net-_Q11-Pad1_ Net-_Q11-Pad1_ Net-_Q11-Pad3_ eSim_PNP
.end
