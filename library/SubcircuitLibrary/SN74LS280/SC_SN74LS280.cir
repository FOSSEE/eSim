* C:\FOSSEE2\eSim\library\SubcircuitLibrary\SC_SN74LS280\SC_SN74LS280.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 07/05/25 15:06:53

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
X1  Net-_U12-Pad1_ Net-_U13-Pad1_ Net-_U11-Pad2_ Net-_X1-Pad4_ 3_and
X2  Net-_U11-Pad1_ Net-_U13-Pad1_ Net-_U12-Pad2_ Net-_X13-Pad2_ 3_and
X3  Net-_U12-Pad1_ Net-_U11-Pad1_ Net-_U13-Pad2_ Net-_X13-Pad3_ 3_and
X4  Net-_U13-Pad2_ Net-_U12-Pad2_ Net-_U11-Pad2_ Net-_X13-Pad4_ 3_and
X13  Net-_X1-Pad4_ Net-_X13-Pad2_ Net-_X13-Pad3_ Net-_X13-Pad4_ Net-_U20-Pad1_ 4_OR
U20  Net-_U20-Pad1_ Net-_U20-Pad2_ d_inverter
U2  Net-_U1-Pad8_ Net-_U11-Pad1_ d_inverter
U3  Net-_U1-Pad9_ Net-_U12-Pad1_ d_inverter
U4  Net-_U1-Pad10_ Net-_U13-Pad1_ d_inverter
U11  Net-_U11-Pad1_ Net-_U11-Pad2_ d_inverter
U12  Net-_U12-Pad1_ Net-_U12-Pad2_ d_inverter
U13  Net-_U13-Pad1_ Net-_U13-Pad2_ d_inverter
X5  Net-_U15-Pad1_ Net-_U16-Pad1_ Net-_U14-Pad2_ Net-_X14-Pad1_ 3_and
X6  Net-_U14-Pad1_ Net-_U16-Pad1_ Net-_U15-Pad2_ Net-_X14-Pad2_ 3_and
X7  Net-_U15-Pad1_ Net-_U14-Pad1_ Net-_U16-Pad2_ Net-_X14-Pad3_ 3_and
X8  Net-_U16-Pad2_ Net-_U15-Pad2_ Net-_U14-Pad2_ Net-_X14-Pad4_ 3_and
X14  Net-_X14-Pad1_ Net-_X14-Pad2_ Net-_X14-Pad3_ Net-_X14-Pad4_ Net-_U21-Pad1_ 4_OR
U21  Net-_U21-Pad1_ Net-_U21-Pad2_ d_inverter
U5  Net-_U1-Pad11_ Net-_U14-Pad1_ d_inverter
U6  Net-_U1-Pad12_ Net-_U15-Pad1_ d_inverter
U7  Net-_U1-Pad13_ Net-_U16-Pad1_ d_inverter
U14  Net-_U14-Pad1_ Net-_U14-Pad2_ d_inverter
U15  Net-_U15-Pad1_ Net-_U15-Pad2_ d_inverter
U16  Net-_U16-Pad1_ Net-_U16-Pad2_ d_inverter
X9  Net-_U18-Pad1_ Net-_U10-Pad2_ Net-_U17-Pad2_ Net-_X15-Pad1_ 3_and
X10  Net-_U17-Pad1_ Net-_U10-Pad2_ Net-_U18-Pad2_ Net-_X10-Pad4_ 3_and
X11  Net-_U18-Pad1_ Net-_U17-Pad1_ Net-_U19-Pad2_ Net-_X11-Pad4_ 3_and
X12  Net-_U19-Pad2_ Net-_U18-Pad2_ Net-_U17-Pad2_ Net-_X12-Pad4_ 3_and
X15  Net-_X15-Pad1_ Net-_X10-Pad4_ Net-_X11-Pad4_ Net-_X12-Pad4_ Net-_U22-Pad1_ 4_OR
U22  Net-_U22-Pad1_ Net-_U22-Pad2_ d_inverter
U8  Net-_U1-Pad1_ Net-_U17-Pad1_ d_inverter
U9  Net-_U1-Pad2_ Net-_U18-Pad1_ d_inverter
U10  Net-_U1-Pad4_ Net-_U10-Pad2_ d_inverter
U17  Net-_U17-Pad1_ Net-_U17-Pad2_ d_inverter
U18  Net-_U18-Pad1_ Net-_U18-Pad2_ d_inverter
U19  Net-_U10-Pad2_ Net-_U19-Pad2_ d_inverter
X16  Net-_U21-Pad2_ Net-_U22-Pad2_ Net-_U23-Pad2_ Net-_X16-Pad4_ 3_and
X17  Net-_U20-Pad2_ Net-_U22-Pad2_ Net-_U24-Pad2_ Net-_X17-Pad4_ 3_and
X18  Net-_U20-Pad2_ Net-_U21-Pad2_ Net-_U25-Pad2_ Net-_X18-Pad4_ 3_and
X19  Net-_U23-Pad2_ Net-_U24-Pad2_ Net-_U25-Pad2_ Net-_X19-Pad4_ 3_and
X24  Net-_X16-Pad4_ Net-_X17-Pad4_ Net-_X18-Pad4_ Net-_X19-Pad4_ Net-_U26-Pad1_ 4_OR
U23  Net-_U20-Pad2_ Net-_U23-Pad2_ d_inverter
X20  Net-_U24-Pad2_ Net-_U25-Pad2_ Net-_U20-Pad2_ Net-_X20-Pad4_ 3_and
X21  Net-_U21-Pad2_ Net-_U23-Pad2_ Net-_U25-Pad2_ Net-_X21-Pad4_ 3_and
X22  Net-_U24-Pad2_ Net-_U23-Pad2_ Net-_U22-Pad2_ Net-_X22-Pad4_ 3_and
X23  Net-_U21-Pad2_ Net-_U20-Pad2_ Net-_U22-Pad2_ Net-_X23-Pad4_ 3_and
X25  Net-_X20-Pad4_ Net-_X21-Pad4_ Net-_X22-Pad4_ Net-_X23-Pad4_ Net-_U27-Pad1_ 4_OR
U24  Net-_U21-Pad2_ Net-_U24-Pad2_ d_inverter
U26  Net-_U26-Pad1_ Net-_U1-Pad5_ d_inverter
U27  Net-_U27-Pad1_ Net-_U1-Pad6_ d_inverter
U25  Net-_U22-Pad2_ Net-_U25-Pad2_ d_inverter
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ ? Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ ? Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ ? PORT

.end
