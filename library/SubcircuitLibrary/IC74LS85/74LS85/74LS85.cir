.title KiCad schematic
U33 Net-_U33-Pad1_ Net-_U27-Pad2_ Net-_U1-Pad5_ d_and
U1 Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ GND Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ GND PORT
X13 Net-_U20-Pad2_ Net-_U21-Pad2_ Net-_U22-Pad2_ Net-_U23-Pad2_ Net-_U30-Pad2_ Net-_U33-Pad1_ 5_and
X11 Net-_U14-Pad3_ Net-_U15-Pad3_ Net-_U1-Pad3_ Net-_X11-Pad4_ Net-_U17-Pad3_ Net-_U1-Pad6_ 5_and
U17 Net-_U12-Pad3_ Net-_U13-Pad3_ Net-_U17-Pad3_ d_nor
U12 Net-_U1-Pad10_ Net-_U12-Pad2_ Net-_U12-Pad3_ d_and
U5 Net-_U1-Pad10_ Net-_U1-Pad9_ Net-_U12-Pad2_ d_nand
X10 Net-_U14-Pad3_ Net-_U4-Pad3_ Net-_U1-Pad13_ Net-_U28-Pad1_ 3_and
U13 Net-_U12-Pad2_ Net-_U1-Pad9_ Net-_U13-Pad3_ d_and
U19 Net-_U18-Pad2_ Net-_U1-Pad15_ Net-_U19-Pad3_ d_and
X12 Net-_U25-Pad2_ Net-_U24-Pad2_ Net-_U26-Pad2_ Net-_U31-Pad2_ Net-_U28-Pad2_ Net-_U32-Pad1_ 5_and
U29 Net-_U19-Pad3_ Net-_U29-Pad2_ d_inverter
U28 Net-_U28-Pad1_ Net-_U28-Pad2_ d_inverter
U32 Net-_U32-Pad1_ Net-_U29-Pad2_ Net-_U1-Pad7_ d_and
X7 Net-_U1-Pad4_ Net-_U17-Pad3_ Net-_U15-Pad3_ Net-_X11-Pad4_ Net-_U14-Pad3_ Net-_U24-Pad1_ 5_and
X8 Net-_X11-Pad4_ Net-_U15-Pad3_ Net-_U14-Pad3_ Net-_U12-Pad2_ Net-_U1-Pad10_ Net-_U26-Pad1_ 5_and
U24 Net-_U24-Pad1_ Net-_U24-Pad2_ d_inverter
U26 Net-_U26-Pad1_ Net-_U26-Pad2_ d_inverter
U31 Net-_U31-Pad1_ Net-_U31-Pad2_ d_inverter
X9 Net-_U15-Pad3_ Net-_U14-Pad3_ Net-_U10-Pad2_ Net-_U1-Pad12_ Net-_U31-Pad1_ 4_and
U11 Net-_U10-Pad2_ Net-_U1-Pad11_ Net-_U11-Pad3_ d_and
U3 Net-_U1-Pad12_ Net-_U1-Pad11_ Net-_U10-Pad2_ d_nand
U4 Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U4-Pad3_ d_nand
U16 Net-_U10-Pad3_ Net-_U11-Pad3_ Net-_X11-Pad4_ d_nor
U10 Net-_U1-Pad12_ Net-_U10-Pad2_ Net-_U10-Pad3_ d_and
U9 Net-_U4-Pad3_ Net-_U1-Pad14_ Net-_U15-Pad2_ d_and
U8 Net-_U1-Pad13_ Net-_U4-Pad3_ Net-_U15-Pad1_ d_and
U15 Net-_U15-Pad1_ Net-_U15-Pad2_ Net-_U15-Pad3_ d_nor
U7 Net-_U18-Pad2_ Net-_U1-Pad1_ Net-_U14-Pad2_ d_and
U14 Net-_U14-Pad1_ Net-_U14-Pad2_ Net-_U14-Pad3_ d_nor
U6 Net-_U1-Pad15_ Net-_U18-Pad2_ Net-_U14-Pad1_ d_and
U2 Net-_U1-Pad15_ Net-_U1-Pad1_ Net-_U18-Pad2_ d_nand
X6 Net-_U1-Pad3_ Net-_U17-Pad3_ Net-_X11-Pad4_ Net-_U15-Pad3_ Net-_U14-Pad3_ Net-_U25-Pad1_ 5_and
U25 Net-_U25-Pad1_ Net-_U25-Pad2_ d_inverter
X4 Net-_U14-Pad3_ Net-_U15-Pad3_ Net-_X11-Pad4_ Net-_U17-Pad3_ Net-_U1-Pad2_ Net-_U30-Pad1_ 5_and
U30 Net-_U30-Pad1_ Net-_U30-Pad2_ d_inverter
U27 Net-_U27-Pad1_ Net-_U27-Pad2_ d_inverter
X5 Net-_U14-Pad3_ Net-_U15-Pad3_ Net-_X11-Pad4_ Net-_U17-Pad3_ Net-_U1-Pad3_ Net-_U27-Pad1_ 5_and
U21 Net-_U21-Pad1_ Net-_U21-Pad2_ d_inverter
X1 Net-_U1-Pad14_ Net-_U4-Pad3_ Net-_U14-Pad3_ Net-_U21-Pad1_ 3_and
U18 Net-_U1-Pad1_ Net-_U18-Pad2_ Net-_U18-Pad3_ d_and
U20 Net-_U18-Pad3_ Net-_U20-Pad2_ d_inverter
U22 Net-_U22-Pad1_ Net-_U22-Pad2_ d_inverter
X3 Net-_U1-Pad9_ Net-_U12-Pad2_ Net-_U14-Pad3_ Net-_U15-Pad3_ Net-_X11-Pad4_ Net-_U23-Pad1_ 5_and
U23 Net-_U23-Pad1_ Net-_U23-Pad2_ d_inverter
X2 Net-_U1-Pad11_ Net-_U10-Pad2_ Net-_U14-Pad3_ Net-_U15-Pad3_ Net-_U22-Pad1_ 4_and
.end
