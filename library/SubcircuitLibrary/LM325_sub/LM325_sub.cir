* C:\Users\AJAY\OneDrive\Desktop\FOSSEE2.3\eSim\library\SubcircuitLibrary\LM325_sub\LM325_sub.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 10/22/25 19:11:53

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
Q7  Net-_Q13-Pad2_ Net-_Q13-Pad2_ Net-_Q13-Pad3_ eSim_PNP
Q13  Net-_C2-Pad1_ Net-_Q13-Pad2_ Net-_Q13-Pad3_ eSim_PNP
Q20  Net-_Q16-Pad1_ Net-_Q13-Pad2_ Net-_Q13-Pad3_ eSim_PNP
Q18  Net-_Q10-Pad2_ Net-_Q18-Pad2_ Net-_C2-Pad1_ eSim_PNP
Q19  Net-_J1-Pad2_ Net-_C2-Pad1_ Net-_Q16-Pad1_ eSim_PNP
Q10  Net-_C2-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
Q14  Net-_Q10-Pad2_ Net-_Q10-Pad2_ Net-_Q14-Pad3_ eSim_NPN
C2  Net-_C2-Pad1_ Net-_C2-Pad2_ 20p
R8  Net-_C1-Pad1_ Net-_C1-Pad2_ 7.5k
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 10p
Q11  Net-_J1-Pad2_ Net-_C1-Pad1_ Net-_Q10-Pad3_ eSim_PNP
Q15  Net-_J1-Pad2_ Net-_C2-Pad2_ Net-_Q14-Pad3_ eSim_PNP
Q5  Net-_Q13-Pad2_ Net-_C1-Pad2_ Net-_Q1-Pad1_ eSim_NPN
Q36  Net-_Q13-Pad3_ Net-_Q16-Pad1_ Net-_Q36-Pad3_ eSim_NPN
Q38  Net-_Q13-Pad3_ Net-_Q36-Pad3_ Net-_Q29-Pad2_ eSim_NPN
Q29  Net-_Q16-Pad1_ Net-_Q29-Pad2_ Net-_Q29-Pad3_ eSim_NPN
R27  Net-_Q29-Pad2_ Net-_Q29-Pad3_ 2.25
R24  Net-_Q36-Pad3_ Net-_Q29-Pad3_ 10k
Q27  Net-_Q16-Pad1_ Net-_Q27-Pad2_ Net-_Q18-Pad2_ eSim_NPN
R28  Net-_Q29-Pad3_ Net-_R22-Pad2_ 300
R22  Net-_Q27-Pad2_ Net-_R22-Pad2_ 1k
R29  Net-_Q18-Pad2_ Net-_C2-Pad2_ 15k
Q30  Net-_Q18-Pad2_ Net-_Q18-Pad2_ Net-_C1-Pad2_ eSim_PNP
R30  Net-_C2-Pad2_ Net-_C3-Pad1_ 15k
R23  Net-_C1-Pad2_ Net-_Q28-Pad1_ 2k
Q31  Net-_C1-Pad2_ Net-_C1-Pad2_ Net-_C3-Pad1_ eSim_PNP
R16  Net-_C1-Pad2_ Net-_Q34-Pad2_ 15k
R17  Net-_Q34-Pad2_ Net-_C3-Pad1_ 15k
Q23  Net-_Q23-Pad1_ Net-_Q2-Pad1_ Net-_Q23-Pad3_ eSim_PNP
R13  Net-_C1-Pad2_ Net-_Q23-Pad3_ 390
Q21  Net-_Q2-Pad1_ Net-_Q2-Pad1_ Net-_C1-Pad2_ eSim_PNP
C3  Net-_C3-Pad1_ Net-_C3-Pad2_ 30p
Q33  Net-_Q28-Pad1_ Net-_C3-Pad2_ Net-_Q33-Pad3_ eSim_NPN
Q37  Net-_Q28-Pad1_ Net-_Q33-Pad3_ Net-_C4-Pad2_ eSim_NPN
Q39  Net-_C4-Pad1_ Net-_C4-Pad2_ Net-_Q32-Pad2_ eSim_NPN
C4  Net-_C4-Pad1_ Net-_C4-Pad2_ 5p
R25  Net-_C4-Pad2_ Net-_Q32-Pad3_ 10k
R21  Net-_Q33-Pad3_ Net-_Q32-Pad3_ 20k
Q32  Net-_C3-Pad2_ Net-_Q32-Pad2_ Net-_Q32-Pad3_ eSim_NPN
R31  Net-_Q32-Pad2_ Net-_Q32-Pad3_ 2.25
R20  Net-_Q23-Pad1_ Net-_Q34-Pad3_ 3.4k
Q34  Net-_Q28-Pad2_ Net-_Q34-Pad2_ Net-_Q34-Pad3_ eSim_PNP
R14  Net-_Q23-Pad1_ Net-_Q24-Pad3_ 3.4k
Q24  Net-_C3-Pad2_ Net-_Q24-Pad2_ Net-_Q24-Pad3_ eSim_PNP
Q28  Net-_Q28-Pad1_ Net-_Q28-Pad2_ Net-_Q25-Pad2_ eSim_NPN
Q35  Net-_Q28-Pad2_ Net-_Q25-Pad2_ Net-_Q35-Pad3_ eSim_NPN
Q25  Net-_C3-Pad2_ Net-_Q25-Pad2_ Net-_Q25-Pad3_ eSim_NPN
R18  Net-_Q25-Pad2_ Net-_J1-Pad2_ 20k
R15  Net-_Q25-Pad3_ Net-_J1-Pad2_ 2k
R19  Net-_J1-Pad2_ Net-_Q35-Pad3_ 2k
R32  Net-_Q32-Pad3_ Net-_R26-Pad2_ 300
R26  Net-_Q26-Pad2_ Net-_R26-Pad2_ 1k
Q22  Net-_C3-Pad2_ Net-_Q17-Pad2_ Net-_J1-Pad2_ eSim_NPN
Q26  Net-_C3-Pad2_ Net-_Q26-Pad2_ Net-_J1-Pad2_ eSim_NPN
Q17  Net-_Q17-Pad1_ Net-_Q17-Pad2_ Net-_J1-Pad2_ eSim_NPN
R11  Net-_Q16-Pad3_ Net-_Q17-Pad1_ 10k
Q16  Net-_Q16-Pad1_ Net-_J1-Pad3_ Net-_Q16-Pad3_ eSim_NPN
R12  Net-_Q12-Pad1_ Net-_Q24-Pad2_ 7.5k
Q12  Net-_Q12-Pad1_ Net-_Q12-Pad1_ Net-_Q12-Pad3_ eSim_NPN
R10  Net-_C3-Pad1_ Net-_Q12-Pad3_ 23k
R9  Net-_J1-Pad2_ Net-_Q17-Pad2_ 3k
Q9  Net-_Q17-Pad2_ Net-_Q4-Pad1_ Net-_Q9-Pad3_ eSim_PNP
R7  Net-_Q4-Pad2_ Net-_Q17-Pad2_ 3k
Q8  Net-_Q4-Pad1_ Net-_Q4-Pad2_ Net-_J1-Pad2_ eSim_NPN
Q4  Net-_Q4-Pad1_ Net-_Q4-Pad2_ Net-_J1-Pad2_ eSim_NPN
R6  Net-_Q9-Pad3_ Net-_Q4-Pad1_ 1.5k
R5  Net-_Q6-Pad2_ Net-_Q12-Pad1_ 6.9k
R4  Net-_R4-Pad1_ Net-_Q6-Pad2_ 2k
U2  Net-_R4-Pad1_ Net-_C1-Pad2_ zener
Q6  Net-_C1-Pad2_ Net-_Q6-Pad2_ Net-_Q12-Pad1_ eSim_NPN
R3  Net-_Q3-Pad3_ Net-_Q1-Pad3_ 3.9k
Q3  Net-_Q12-Pad1_ Net-_J1-Pad3_ Net-_Q3-Pad3_ eSim_NPN
Q2  Net-_Q2-Pad1_ Net-_J1-Pad3_ Net-_Q1-Pad3_ eSim_NPN
Q1  Net-_Q1-Pad1_ Net-_J1-Pad3_ Net-_Q1-Pad3_ eSim_NPN
R2  Net-_Q4-Pad2_ Net-_J1-Pad2_ 515
R1  Net-_Q1-Pad3_ Net-_Q4-Pad2_ 11k
U1  Net-_J1-Pad2_ Net-_J1-Pad3_ zener
J1  Net-_C1-Pad2_ Net-_J1-Pad2_ Net-_J1-Pad3_ eSim_NJF
U3  Net-_Q29-Pad3_ ? Net-_Q13-Pad3_ Net-_J1-Pad2_ Net-_R26-Pad2_ Net-_C3-Pad1_ Net-_C4-Pad1_ Net-_Q32-Pad3_ ? Net-_Q12-Pad1_ Net-_C1-Pad2_ ? Net-_R22-Pad2_ Net-_Q18-Pad2_ PORT

.end
