* C:\FOSSEE\eSim\library\SubcircuitLibrary\74HC393\74HC393.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 12/06/25 15:50:59

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U9  Net-_U11-Pad1_ Net-_U5-Pad3_ Net-_U1-Pad3_ Net-_U11-Pad4_ Net-_U11-Pad2_ ? d_tff
U11  Net-_U11-Pad1_ Net-_U11-Pad2_ Net-_U1-Pad3_ Net-_U11-Pad4_ Net-_U11-Pad5_ ? d_tff
U13  Net-_U11-Pad1_ Net-_U11-Pad5_ Net-_U1-Pad3_ Net-_U11-Pad4_ Net-_U13-Pad5_ ? d_tff
U15  Net-_U11-Pad1_ Net-_U13-Pad5_ Net-_U1-Pad3_ Net-_U11-Pad4_ Net-_U15-Pad5_ ? d_tff
U5  Net-_U1-Pad2_ Net-_U1-Pad4_ Net-_U5-Pad3_ Net-_U5-Pad4_ adc_bridge_2
U3  Net-_U1-Pad1_ Net-_U11-Pad1_ adc_bridge_1
U7  Net-_U5-Pad4_ Net-_U11-Pad4_ d_inverter
U8  Net-_U10-Pad1_ Net-_U4-Pad3_ Net-_U1-Pad7_ Net-_U10-Pad4_ Net-_U10-Pad2_ ? d_tff
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ Net-_U1-Pad7_ Net-_U10-Pad4_ Net-_U10-Pad5_ ? d_tff
U12  Net-_U10-Pad1_ Net-_U10-Pad5_ Net-_U1-Pad7_ Net-_U10-Pad4_ Net-_U12-Pad5_ ? d_tff
U14  Net-_U10-Pad1_ Net-_U12-Pad5_ Net-_U1-Pad7_ Net-_U10-Pad4_ Net-_U14-Pad5_ ? d_tff
U4  Net-_U1-Pad6_ Net-_U1-Pad8_ Net-_U4-Pad3_ Net-_U4-Pad4_ adc_bridge_2
U2  Net-_U1-Pad5_ Net-_U10-Pad1_ adc_bridge_1
U6  Net-_U4-Pad4_ Net-_U10-Pad4_ d_inverter
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ Net-_U1-Pad16_ PORT
U16  Net-_U11-Pad2_ Net-_U11-Pad5_ Net-_U13-Pad5_ Net-_U15-Pad5_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ dac_bridge_4
U17  Net-_U10-Pad2_ Net-_U10-Pad5_ Net-_U12-Pad5_ Net-_U14-Pad5_ Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ Net-_U1-Pad16_ dac_bridge_4

.end
