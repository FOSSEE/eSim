* E:\FOSSEE\eSim\library\SubcircuitLibrary\MC1445L\MC1445L.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/04/25 11:14:53

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
Q4  Net-_Q4-Pad1_ Net-_Q4-Pad2_ Net-_Q4-Pad3_ eSim_NPN
R4  Net-_Q1-Pad3_ Net-_Q2-Pad1_ 0.02k
R5  Net-_Q2-Pad1_ Net-_Q4-Pad3_ 0.02k
R1  Net-_Q10-Pad1_ Net-_D1-Pad1_ 2.5k
R2  Net-_D1-Pad1_ Net-_Q2-Pad2_ 7.8k
R3  Net-_Q2-Pad2_ Net-_R13-Pad2_ 3.8k
Q2  Net-_Q2-Pad1_ Net-_Q2-Pad2_ Net-_Q2-Pad3_ eSim_NPN
Q6  Net-_Q6-Pad1_ Net-_D2-Pad1_ Net-_Q2-Pad3_ eSim_NPN
Q3  Net-_Q2-Pad3_ Net-_D2-Pad1_ Net-_Q3-Pad3_ eSim_NPN
R6  Net-_Q3-Pad3_ Net-_R13-Pad2_ 0.19k
Q5  Net-_Q1-Pad1_ Net-_Q5-Pad2_ Net-_Q5-Pad3_ eSim_NPN
Q7  Net-_Q4-Pad1_ Net-_Q7-Pad2_ Net-_Q7-Pad3_ eSim_NPN
R10  Net-_Q6-Pad1_ Net-_Q7-Pad3_ 0.02k
D1  Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
R7  Net-_R11-Pad1_ Net-_Q1-Pad1_ 1k
R8  Net-_Q5-Pad3_ Net-_Q6-Pad1_ 0.02k
R11  Net-_R11-Pad1_ Net-_Q4-Pad1_ 1k
R9  Net-_Q10-Pad1_ Net-_R11-Pad1_ 0.85k
R12  Net-_Q10-Pad1_ Net-_D2-Pad1_ 15k
R13  Net-_D2-Pad1_ Net-_R13-Pad2_ 4k
Q8  Net-_Q10-Pad1_ Net-_Q1-Pad1_ Net-_Q10-Pad2_ eSim_NPN
R14  Net-_Q10-Pad2_ Net-_D2-Pad1_ 9k
Q9  Net-_Q10-Pad1_ Net-_Q4-Pad1_ Net-_Q11-Pad2_ eSim_NPN
R15  Net-_Q11-Pad2_ Net-_D2-Pad1_ 9k
D2  Net-_D2-Pad1_ Net-_D2-Pad2_ eSim_Diode
R16  Net-_D2-Pad2_ Net-_R13-Pad2_ 0.5k
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
Q11  Net-_Q10-Pad1_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_NPN
R17  Net-_Q10-Pad3_ Net-_R13-Pad2_ 5k
R18  Net-_Q11-Pad3_ Net-_R13-Pad2_ 5k
U1  Net-_D1-Pad2_ Net-_Q4-Pad2_ Net-_Q1-Pad2_ Net-_Q7-Pad2_ Net-_Q5-Pad2_ Net-_Q11-Pad3_ Net-_Q10-Pad3_ Net-_Q10-Pad1_ Net-_R13-Pad2_ PORT

.end
