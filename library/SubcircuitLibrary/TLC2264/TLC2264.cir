* C:\FOSSEE\eSim\library\SubcircuitLibrary\TLC2264\TLC2264.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 01/19/25 19:51:29

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
M4  Net-_M11-Pad1_ Net-_M1-Pad3_ Net-_M4-Pad3_ Net-_D1-Pad2_ mosfet_n
M2  Net-_M1-Pad3_ Net-_M1-Pad3_ Net-_M2-Pad3_ Net-_D1-Pad2_ mosfet_n
M1  Net-_M1-Pad1_ Net-_M1-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad4_ mosfet_p
R1  Net-_M2-Pad3_ Net-_D1-Pad2_ 10k
R2  Net-_M4-Pad3_ Net-_D1-Pad2_ 10k
M5  Net-_M1-Pad1_ Net-_M5-Pad2_ Net-_M11-Pad1_ Net-_M1-Pad4_ mosfet_p
M6  Net-_M6-Pad1_ Net-_M14-Pad1_ Net-_M1-Pad4_ Net-_M1-Pad4_ mosfet_p
M3  Net-_M1-Pad1_ Net-_M14-Pad1_ Net-_M1-Pad4_ Net-_M1-Pad4_ mosfet_p
M7  Net-_M6-Pad1_ Net-_M11-Pad1_ Net-_D1-Pad2_ Net-_D1-Pad2_ mosfet_n
M8  Net-_M6-Pad1_ Net-_M6-Pad1_ Net-_D1-Pad2_ Net-_D1-Pad2_ mosfet_n
M9  Net-_M13-Pad2_ Net-_M6-Pad1_ Net-_D1-Pad2_ Net-_D1-Pad2_ mosfet_n
M11  Net-_M11-Pad1_ Net-_M11-Pad2_ Net-_D1-Pad2_ Net-_D1-Pad2_ mosfet_n
R4  Net-_M11-Pad2_ Net-_D1-Pad2_ 10k
M12  Net-_C1-Pad2_ Net-_M11-Pad1_ Net-_M11-Pad2_ Net-_D1-Pad2_ mosfet_n
M14  Net-_M14-Pad1_ Net-_M14-Pad2_ Net-_M14-Pad3_ Net-_D1-Pad2_ mosfet_n
R5  Net-_M14-Pad3_ Net-_D1-Pad2_ 10k
M13  Net-_C1-Pad2_ Net-_M13-Pad2_ Net-_M1-Pad4_ Net-_M1-Pad4_ mosfet_p
M10  Net-_M10-Pad1_ Net-_M10-Pad1_ Net-_M1-Pad4_ Net-_M1-Pad4_ mosfet_p
R3  Net-_C1-Pad1_ Net-_M11-Pad1_ 10k
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 10u
M15  Net-_M14-Pad1_ Net-_M14-Pad1_ Net-_M1-Pad4_ Net-_M1-Pad4_ mosfet_p
M17  Net-_M14-Pad2_ Net-_M14-Pad1_ Net-_M1-Pad4_ Net-_M1-Pad4_ mosfet_p
M16  Net-_M14-Pad2_ Net-_M14-Pad2_ Net-_D1-Pad1_ Net-_D1-Pad2_ mosfet_n
D1  Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
U1  Net-_M5-Pad2_ Net-_M1-Pad2_ Net-_M1-Pad4_ Net-_D1-Pad2_ Net-_C1-Pad2_ PORT

.end
