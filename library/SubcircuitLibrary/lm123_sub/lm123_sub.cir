* C:\FOSSEE\eSim\library\SubcircuitLibrary\lm123_sub\lm123_sub.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 03/06/2024 11:06:50 AM

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
Q2  Net-_J1-Pad1_ Net-_J1-Pad1_ Net-_Q2-Pad3_ eSim_PNP
Q3  Net-_Q1-Pad2_ Net-_J1-Pad1_ Net-_Q2-Pad3_ eSim_PNP
Q5  Net-_Q10-Pad1_ Net-_J1-Pad1_ Net-_Q2-Pad3_ eSim_PNP
J1  Net-_J1-Pad1_ Net-_J1-Pad2_ Net-_J1-Pad3_ jfet_n
R1  Net-_Q4-Pad2_ Net-_J1-Pad3_ 4k
R2  Net-_J1-Pad2_ Net-_Q4-Pad2_ 250
U2  Net-_J1-Pad2_ Net-_Q1-Pad2_ zener
Q1  Net-_J1-Pad1_ Net-_Q1-Pad2_ Net-_J1-Pad3_ eSim_NPN
Q4  Net-_Q10-Pad1_ Net-_Q4-Pad2_ Net-_J1-Pad2_ eSim_NPN
R3  Net-_J1-Pad2_ Net-_Q6-Pad3_ 1k
Q6  Net-_Q6-Pad1_ Net-_Q6-Pad2_ Net-_Q6-Pad3_ eSim_NPN
R4  Net-_Q6-Pad1_ Net-_Q9-Pad3_ 2k
R5  Net-_Q6-Pad2_ Net-_Q9-Pad3_ 1.32k
R6  Net-_Q10-Pad2_ Net-_Q6-Pad2_ 100
Q7  Net-_Q10-Pad2_ Net-_Q6-Pad3_ Net-_Q7-Pad3_ eSim_NPN
R7  Net-_J1-Pad2_ Net-_Q7-Pad3_ 100
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
R8  Net-_J1-Pad2_ Net-_Q10-Pad3_ 12k
R10  Net-_J1-Pad2_ Net-_Q11-Pad3_ 1k
Q11  Net-_C1-Pad1_ Net-_Q10-Pad3_ Net-_Q11-Pad3_ eSim_NPN
Q14  Net-_Q13-Pad3_ Net-_Q13-Pad3_ Net-_Q14-Pad3_ eSim_NPN
R11  Net-_J1-Pad2_ Net-_Q14-Pad3_ 4k
Q13  Net-_C1-Pad2_ Net-_C1-Pad1_ Net-_Q13-Pad3_ eSim_NPN
Q16  Net-_C1-Pad2_ Net-_Q13-Pad3_ Net-_J1-Pad2_ eSim_NPN
R9  Net-_C1-Pad1_ Net-_Q12-Pad3_ 20k
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 30pF
Q12  Net-_Q12-Pad1_ Net-_Q12-Pad2_ Net-_Q12-Pad3_ eSim_NPN
Q9  Net-_Q6-Pad1_ Net-_Q6-Pad1_ Net-_Q9-Pad3_ eSim_NPN
Q8  Net-_J1-Pad1_ Net-_Q12-Pad1_ Net-_Q6-Pad1_ eSim_NPN
R14  Net-_Q12-Pad2_ Net-_Q12-Pad1_ 50k
R15  Net-_Q20-Pad3_ Net-_Q12-Pad2_ 500
Q20  Net-_Q12-Pad1_ Net-_Q12-Pad1_ Net-_Q20-Pad3_ eSim_NPN
R16  Net-_J1-Pad2_ Net-_Q20-Pad3_ 20k
R19  Net-_J1-Pad2_ Net-_Q12-Pad1_ 4k
U4  Net-_J1-Pad2_ Net-_Q12-Pad1_ zener
Q19  Net-_C2-Pad1_ Net-_C2-Pad2_ Net-_Q12-Pad1_ eSim_NPN
Q17  Net-_J1-Pad2_ Net-_C1-Pad2_ Net-_Q10-Pad1_ eSim_PNP
R12  Net-_C1-Pad2_ Net-_Q15-Pad3_ 1k
Q15  Net-_Q10-Pad1_ Net-_Q10-Pad1_ Net-_Q15-Pad3_ eSim_NPN
Q18  Net-_J1-Pad2_ Net-_C2-Pad1_ Net-_Q10-Pad1_ eSim_PNP
R13  Net-_C2-Pad1_ Net-_Q10-Pad1_ 2k
C2  Net-_C2-Pad1_ Net-_C2-Pad2_ 10pF
R17  Net-_C2-Pad2_ Net-_Q21-Pad1_ 2k
R18  Net-_Q21-Pad1_ Net-_Q21-Pad2_ 200
Q21  Net-_Q21-Pad1_ Net-_Q21-Pad2_ Net-_Q21-Pad3_ eSim_NPN
R20  Net-_Q21-Pad2_ Net-_Q10-Pad1_ 6k
R22  Net-_Q21-Pad3_ Net-_Q23-Pad3_ 50
R21  Net-_Q21-Pad3_ Net-_R21-Pad2_ 50k
R24  Net-_Q12-Pad1_ Net-_Q23-Pad3_ 0.03
R23  Net-_Q23-Pad3_ Net-_Q22-Pad3_ 1k
Q22  Net-_Q2-Pad3_ Net-_Q10-Pad1_ Net-_Q22-Pad3_ eSim_NPN
Q23  Net-_Q2-Pad3_ Net-_Q22-Pad3_ Net-_Q23-Pad3_ eSim_NPN
U3  Net-_R21-Pad2_ Net-_Q2-Pad3_ zener
U1  Net-_Q2-Pad3_ Net-_Q12-Pad1_ Net-_J1-Pad2_ PORT

.end
