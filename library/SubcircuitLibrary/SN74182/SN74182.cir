* C:\FOSSEE\eSim\library\SubcircuitLibrary\SN74182\SN74182.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 07/07/25 14:25:56

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
X1  Net-_U1-Pad6_ Net-_U1-Pad15_ Net-_U1-Pad2_ Net-_U1-Pad4_ Net-_U1-Pad7_ 4_OR
X6  Net-_U1-Pad5_ Net-_U1-Pad14_ Net-_U1-Pad1_ Net-_U1-Pad3_ Net-_X10-Pad1_ 4_and
X2  Net-_U1-Pad15_ Net-_U1-Pad5_ Net-_U1-Pad14_ Net-_X10-Pad3_ 3_and
X7  Net-_U1-Pad2_ Net-_U1-Pad5_ Net-_U1-Pad14_ Net-_U1-Pad1_ Net-_X10-Pad2_ 4_and
U3  Net-_U1-Pad6_ Net-_U1-Pad5_ Net-_U3-Pad3_ d_and
X10  Net-_X10-Pad1_ Net-_X10-Pad2_ Net-_X10-Pad3_ Net-_U3-Pad3_ Net-_U1-Pad10_ 4_OR
X8  Net-_U1-Pad14_ Net-_U1-Pad1_ Net-_U1-Pad3_ Net-_U2-Pad2_ Net-_X11-Pad1_ 4_and
X3  Net-_U1-Pad2_ Net-_U1-Pad14_ Net-_U1-Pad1_ Net-_X11-Pad3_ 3_and
X9  Net-_U1-Pad4_ Net-_U1-Pad14_ Net-_U1-Pad1_ Net-_U1-Pad3_ Net-_X11-Pad2_ 4_and
U4  Net-_U1-Pad15_ Net-_U1-Pad14_ Net-_U4-Pad3_ d_and
X11  Net-_X11-Pad1_ Net-_X11-Pad2_ Net-_X11-Pad3_ Net-_U4-Pad3_ Net-_U11-Pad1_ 4_OR
U11  Net-_U11-Pad1_ Net-_U1-Pad9_ d_inverter
X4  Net-_U1-Pad1_ Net-_U1-Pad3_ Net-_U2-Pad2_ Net-_U8-Pad1_ 3_and
X5  Net-_U1-Pad4_ Net-_U1-Pad1_ Net-_U1-Pad3_ Net-_U8-Pad2_ 3_and
U5  Net-_U1-Pad2_ Net-_U1-Pad1_ Net-_U10-Pad2_ d_and
U8  Net-_U8-Pad1_ Net-_U8-Pad2_ Net-_U10-Pad1_ d_or
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ Net-_U10-Pad3_ d_or
U12  Net-_U10-Pad3_ Net-_U1-Pad11_ d_inverter
U2  Net-_U1-Pad13_ Net-_U2-Pad2_ d_inverter
U6  Net-_U1-Pad3_ Net-_U2-Pad2_ Net-_U6-Pad3_ d_and
U7  Net-_U1-Pad4_ Net-_U1-Pad3_ Net-_U7-Pad3_ d_and
U9  Net-_U6-Pad3_ Net-_U7-Pad3_ Net-_U1-Pad12_ d_nor
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ ? Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ ? PORT

.end
