* C:\FOSSEE\eSim\library\SubcircuitLibrary\SN74ACT86\SN74ACT86.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/17/25 12:15:21

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U9  Net-_U1-Pad1_ Net-_U5-Pad2_ Net-_U17-Pad1_ d_and
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ d_inverter
U5  Net-_U10-Pad2_ Net-_U5-Pad2_ d_inverter
U10  Net-_U1-Pad2_ Net-_U10-Pad2_ Net-_U10-Pad3_ d_and
U17  Net-_U17-Pad1_ Net-_U10-Pad3_ Net-_U17-Pad3_ d_or
U11  Net-_U11-Pad1_ Net-_U11-Pad2_ Net-_U11-Pad3_ d_and
U2  Net-_U11-Pad1_ Net-_U12-Pad1_ d_inverter
U6  Net-_U12-Pad2_ Net-_U11-Pad2_ d_inverter
U12  Net-_U12-Pad1_ Net-_U12-Pad2_ Net-_U12-Pad3_ d_and
U18  Net-_U11-Pad3_ Net-_U12-Pad3_ Net-_U18-Pad3_ d_or
U13  Net-_U13-Pad1_ Net-_U13-Pad2_ Net-_U13-Pad3_ d_and
U3  Net-_U13-Pad1_ Net-_U14-Pad1_ d_inverter
U7  Net-_U14-Pad2_ Net-_U13-Pad2_ d_inverter
U14  Net-_U14-Pad1_ Net-_U14-Pad2_ Net-_U14-Pad3_ d_and
U19  Net-_U13-Pad3_ Net-_U14-Pad3_ Net-_U19-Pad3_ d_or
U15  Net-_U15-Pad1_ Net-_U15-Pad2_ Net-_U15-Pad3_ d_and
U4  Net-_U15-Pad1_ Net-_U16-Pad1_ d_inverter
U8  Net-_U16-Pad2_ Net-_U15-Pad2_ d_inverter
U16  Net-_U16-Pad1_ Net-_U16-Pad2_ Net-_U16-Pad3_ d_and
U20  Net-_U15-Pad3_ Net-_U16-Pad3_ Net-_U20-Pad3_ d_or
U21  Net-_U1-Pad1_ Net-_U10-Pad2_ Net-_U17-Pad3_ Net-_U11-Pad1_ Net-_U12-Pad2_ Net-_U18-Pad3_ ? Net-_U19-Pad3_ Net-_U13-Pad1_ Net-_U14-Pad2_ Net-_U20-Pad3_ Net-_U15-Pad1_ Net-_U16-Pad2_ ? PORT

.end
