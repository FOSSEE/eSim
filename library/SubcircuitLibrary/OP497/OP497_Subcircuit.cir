* C:\FOSSEE\eSim\library\SubcircuitLibrary\OP497_Subcircuit\OP497_Subcircuit.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 02/04/25 21:20:34

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
R1  Net-_R1-Pad1_ Net-_Q12-Pad1_ 2.5k
Q1  Net-_Q1-Pad1_ ? Net-_Q1-Pad3_ eSim_NPN
Q2  Net-_Q1-Pad1_ Net-_Q1-Pad3_ Net-_Q12-Pad1_ eSim_NPN
Q3  Net-_Q3-Pad1_ Net-_Q12-Pad1_ Net-_C3-Pad2_ eSim_NPN
R2  Net-_R2-Pad1_ Net-_Q1-Pad3_ 2.5k
R3  Net-_Q1-Pad1_ Net-_Q7-Pad3_ 10k
Q6  Net-_Q5-Pad3_ Net-_Q1-Pad3_ Net-_C3-Pad2_ eSim_NPN
Q4  Net-_C1-Pad2_ Net-_C1-Pad1_ Net-_Q3-Pad1_ eSim_NPN
Q5  Net-_C2-Pad1_ Net-_C1-Pad1_ Net-_Q5-Pad3_ eSim_NPN
R4  Net-_C1-Pad1_ Net-_C1-Pad2_ 10k
R5  Net-_C1-Pad1_ Net-_C2-Pad1_ 10k
Q8  Net-_C1-Pad1_ Net-_C1-Pad1_ Net-_Q7-Pad3_ eSim_NPN
Q7  Net-_C3-Pad2_ Net-_C3-Pad2_ Net-_Q7-Pad3_ eSim_PNP
Q9  Net-_Q10-Pad3_ Net-_Q14-Pad1_ Net-_C3-Pad2_ eSim_NPN
Q10  Net-_Q1-Pad3_ Net-_C3-Pad2_ Net-_Q10-Pad3_ eSim_PNP
Q12  Net-_Q12-Pad1_ Net-_C3-Pad2_ Net-_Q10-Pad3_ eSim_PNP
Q14  Net-_Q14-Pad1_ Net-_C3-Pad2_ Net-_Q10-Pad3_ eSim_PNP
Q11  Net-_Q10-Pad3_ Net-_C3-Pad2_ Net-_C1-Pad1_ eSim_PNP
Q13  Net-_C3-Pad2_ Net-_C3-Pad2_ Net-_C1-Pad1_ eSim_PNP
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 10nF
Q15  Net-_Q15-Pad1_ Net-_C1-Pad2_ Net-_C1-Pad1_ eSim_PNP
Q18  Net-_C3-Pad1_ Net-_C2-Pad1_ Net-_C1-Pad1_ eSim_PNP
C2  Net-_C2-Pad1_ Net-_C2-Pad2_ 10pF
R6  Net-_C2-Pad2_ Net-_C3-Pad1_ 10k
D1  Net-_C1-Pad1_ Net-_D1-Pad2_ eSim_Diode
D2  Net-_D1-Pad2_ Net-_C3-Pad2_ eSim_Diode
Q16  Net-_Q15-Pad1_ Net-_Q15-Pad1_ Net-_C3-Pad2_ eSim_NPN
Q17  Net-_C3-Pad1_ Net-_Q15-Pad1_ Net-_C3-Pad2_ eSim_NPN
C3  Net-_C3-Pad1_ Net-_C3-Pad2_ 10nF
Q19  Net-_Q19-Pad1_ Net-_C3-Pad1_ Net-_C3-Pad2_ eSim_NPN
Q21  Net-_C3-Pad2_ Net-_C3-Pad2_ Net-_D3-Pad2_ eSim_PNP
Q23  Net-_C3-Pad2_ Net-_C3-Pad2_ Net-_Q22-Pad3_ eSim_PNP
D3  Net-_C1-Pad1_ Net-_D3-Pad2_ eSim_Diode
Q20  Net-_C1-Pad1_ Net-_C1-Pad1_ Net-_Q19-Pad1_ eSim_NPN
Q22  Net-_C1-Pad1_ Net-_C1-Pad1_ Net-_Q22-Pad3_ eSim_NPN
U1  Net-_R1-Pad1_ Net-_R2-Pad1_ Net-_Q22-Pad3_ Net-_C1-Pad1_ Net-_C3-Pad2_ PORT

.end
