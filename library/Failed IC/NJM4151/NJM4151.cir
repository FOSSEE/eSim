* D:\FOSSEE\eSim\library\SubcircuitLibrary\NJM4151\NJM4151.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 07/08/25 14:42:19

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
Q5  Net-_Q5-Pad1_ Net-_Q5-Pad1_ Net-_J1-Pad3_ eSim_PNP
Q6  Net-_Q6-Pad1_ Net-_Q10-Pad1_ Net-_Q5-Pad1_ eSim_PNP
Q8  Net-_Q10-Pad1_ Net-_Q5-Pad1_ Net-_J1-Pad3_ eSim_PNP
Q9  Net-_Q10-Pad1_ Net-_Q10-Pad3_ Net-_Q9-Pad3_ eSim_NPN
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
R1  Net-_Q10-Pad3_ Net-_Q9-Pad3_ 20k
R2  Net-_Q12-Pad3_ Net-_Q10-Pad2_ 10k
R3  Net-_Q10-Pad2_ Net-_Q13-Pad1_ 5k
Q13  Net-_Q13-Pad1_ Net-_Q13-Pad1_ Net-_Q13-Pad3_ eSim_NPN
Q14  Net-_Q14-Pad1_ Net-_Q14-Pad1_ GND eSim_NPN
R4  Net-_Q13-Pad3_ Net-_Q14-Pad1_ 20k
Q16  Net-_Q13-Pad1_ Net-_Q13-Pad3_ Net-_Q14-Pad1_ eSim_NPN
Q18  Net-_Q18-Pad1_ Net-_Q18-Pad2_ Net-_J1-Pad3_ eSim_PNP
Q19  Net-_Q15-Pad1_ Net-_Q18-Pad2_ Net-_J1-Pad3_ eSim_PNP
Q21  Net-_Q20-Pad2_ Net-_Q18-Pad2_ Net-_J1-Pad3_ eSim_PNP
Q30  Net-_Q27-Pad1_ Net-_Q18-Pad2_ Net-_J1-Pad3_ eSim_PNP
Q32  Net-_Q12-Pad2_ Net-_Q18-Pad2_ Net-_J1-Pad3_ eSim_PNP
Q23  Net-_Q23-Pad1_ Net-_Q18-Pad2_ Net-_J1-Pad3_ eSim_PNP
Q29  Net-_Q29-Pad1_ Net-_Q27-Pad1_ GND eSim_NPN
Q26  Net-_Q10-Pad2_ Net-_Q26-Pad2_ GND eSim_NPN
R7  Net-_Q26-Pad2_ Net-_Q23-Pad1_ 2k
Q27  Net-_Q27-Pad1_ Net-_Q27-Pad2_ GND eSim_NPN
R9  Net-_Q27-Pad2_ Net-_Q23-Pad1_ 2k
Q28  Net-_Q12-Pad2_ Net-_Q28-Pad2_ GND eSim_NPN
R8  Net-_Q28-Pad2_ Net-_Q23-Pad1_ 2k
Q25  Net-_Q23-Pad1_ Net-_Q25-Pad2_ GND eSim_NPN
R10  Net-_Q17-Pad1_ Net-_Q25-Pad2_ 2k
Q35  Net-_Q12-Pad2_ Net-_Q12-Pad2_ Net-_Q34-Pad2_ eSim_NPN
Q34  Net-_Q12-Pad2_ Net-_Q34-Pad2_ Net-_Q34-Pad3_ eSim_NPN
R12  Net-_Q34-Pad3_ Net-_Q34-Pad2_ 20k
U2  GNDPWR Net-_Q34-Pad3_ zener
Q37  Net-_Q17-Pad1_ Net-_Q18-Pad2_ Net-_J1-Pad3_ eSim_PNP
Q40  Net-_Q31-Pad1_ Net-_Q18-Pad2_ Net-_J1-Pad3_ eSim_PNP
Q42  Net-_Q38-Pad3_ Net-_Q18-Pad2_ Net-_J1-Pad3_ eSim_PNP
Q45  Net-_Q24-Pad2_ Net-_Q18-Pad2_ Net-_J1-Pad3_ eSim_PNP
Q47  Net-_Q18-Pad2_ Net-_Q47-Pad2_ GND eSim_NPN
Q46  Net-_J1-Pad3_ Net-_J1-Pad1_ Net-_Q46-Pad3_ eSim_NPN
Q50  Net-_Q47-Pad2_ Net-_J1-Pad1_ Net-_Q46-Pad3_ eSim_NPN
R13  Net-_Q46-Pad3_ GND 12k
U3  GND Net-_J1-Pad1_ zener
J1  Net-_J1-Pad1_ GND Net-_J1-Pad3_ jfet_n
Q1  GND Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_PNP
Q4  GND Net-_Q4-Pad2_ Net-_Q4-Pad3_ eSim_PNP
Q7  Net-_Q11-Pad2_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_NPN
Q11  Net-_Q11-Pad1_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_NPN
Q15  Net-_Q15-Pad1_ Net-_Q11-Pad1_ Net-_Q11-Pad3_ eSim_NPN
Q17  Net-_Q17-Pad1_ Net-_Q17-Pad2_ Net-_Q11-Pad3_ eSim_NPN
R5  Net-_Q15-Pad1_ Net-_Q17-Pad2_ 2k
Q20  Net-_Q15-Pad1_ Net-_Q20-Pad2_ Net-_Q11-Pad3_ eSim_NPN
R6  Net-_Q15-Pad1_ Net-_Q22-Pad2_ 2k
Q22  Net-_Q20-Pad2_ Net-_Q22-Pad2_ Net-_Q11-Pad3_ eSim_NPN
Q24  Net-_Q20-Pad2_ Net-_Q24-Pad2_ Net-_Q11-Pad3_ eSim_NPN
R11  Net-_Q17-Pad1_ Net-_Q31-Pad2_ 2k
Q31  Net-_Q31-Pad1_ Net-_Q31-Pad2_ Net-_Q11-Pad3_ eSim_NPN
Q33  Net-_Q33-Pad1_ Net-_Q31-Pad1_ Net-_Q11-Pad3_ eSim_NPN
Q36  GNDPWR Net-_Q33-Pad1_ Net-_Q36-Pad3_ eSim_PNP
Q38  GND Net-_Q36-Pad3_ Net-_Q38-Pad3_ eSim_PNP
Q39  Net-_Q39-Pad1_ Net-_Q39-Pad1_ Net-_Q11-Pad3_ eSim_NPN
Q41  Net-_Q41-Pad1_ Net-_Q39-Pad1_ Net-_Q11-Pad3_ eSim_NPN
Q44  Net-_Q24-Pad2_ Net-_Q41-Pad1_ Net-_Q11-Pad3_ eSim_NPN
Q48  Net-_Q11-Pad3_ Net-_Q48-Pad2_ Net-_Q48-Pad3_ eSim_PNP
R14  Net-_J1-Pad3_ Net-_Q48-Pad2_ 100
R15  Net-_Q48-Pad2_ Net-_R15-Pad2_ 100
R16  Net-_R15-Pad2_ Net-_Q11-Pad3_ 100
U1  Net-_Q6-Pad1_ Net-_Q9-Pad3_ Net-_Q29-Pad1_ Net-_Q11-Pad3_ Net-_Q33-Pad1_ Net-_Q4-Pad2_ Net-_Q1-Pad2_ Net-_J1-Pad3_ PORT
Q12  Net-_J1-Pad3_ Net-_Q12-Pad2_ Net-_Q12-Pad3_ eSim_NPN
Q51  Net-_Q41-Pad1_ Net-_Q36-Pad3_ Net-_Q38-Pad3_ eSim_PNP
Q52  Net-_Q39-Pad1_ Net-_Q48-Pad3_ Net-_Q38-Pad3_ eSim_PNP
Q53  Net-_Q48-Pad3_ Net-_Q48-Pad3_ Net-_Q38-Pad3_ eSim_PNP
Q54  Net-_Q47-Pad2_ Net-_Q18-Pad2_ Net-_J1-Pad3_ eSim_PNP
Q55  Net-_J1-Pad1_ Net-_Q18-Pad2_ Net-_J1-Pad3_ eSim_PNP
Q2  Net-_Q1-Pad3_ Net-_Q1-Pad3_ Net-_Q18-Pad1_ eSim_PNP
Q3  Net-_Q11-Pad2_ Net-_Q1-Pad3_ Net-_Q18-Pad1_ eSim_PNP
Q49  Net-_Q4-Pad3_ Net-_Q4-Pad3_ Net-_Q18-Pad1_ eSim_PNP
Q43  Net-_Q11-Pad1_ Net-_Q4-Pad3_ Net-_Q18-Pad1_ eSim_PNP

.end
