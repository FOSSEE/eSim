* C:\FOSSEE\eSim\library\SubcircuitLibrary\LM833\LM833.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 05/05/25 12:02:41

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U1  -IN -IN -VEE +VCC +IN +IN OUT OUT PORT
R2  +VCC Net-_Q3-Pad3_ 360
Q3  Net-_Q1-Pad3_ Net-_Q16-Pad1_ Net-_Q3-Pad3_ eSim_PNP
Q1  Net-_Q1-Pad1_ -IN Net-_Q1-Pad3_ eSim_PNP
Q5  Net-_Q4-Pad1_ +IN Net-_Q1-Pad3_ eSim_PNP
Q2  Net-_Q1-Pad1_ Net-_Q1-Pad1_ Net-_C1-Pad1_ eSim_NPN
Q4  Net-_Q4-Pad1_ Net-_Q1-Pad1_ Net-_Q4-Pad3_ eSim_NPN
R1  Net-_C1-Pad1_ -VEE 4.7k
C1  Net-_C1-Pad1_ -VEE 35p
R3  Net-_Q4-Pad3_ -VEE 4.7k
Q6  +VCC Net-_Q4-Pad1_ Net-_Q12-Pad2_ eSim_NPN
R5  Net-_Q12-Pad2_ -VEE 7.5k
R4  Net-_Q4-Pad1_ Net-_C2-Pad1_ 1k
C2  Net-_C2-Pad1_ Net-_C2-Pad2_ 15p
Q8  Net-_Q10-Pad2_ Net-_Q16-Pad1_ +VCC eSim_PNP
Q9  Net-_Q10-Pad2_ Net-_Q10-Pad3_ Net-_C2-Pad2_ eSim_NPN
Q7  Net-_C2-Pad2_ Net-_Q12-Pad2_ Net-_Q7-Pad3_ eSim_NPN
R6  Net-_Q7-Pad3_ -VEE 150
D1  Net-_C2-Pad1_ Net-_D1-Pad2_ eSim_Diode
Q10  +VCC Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
Q11  Net-_Q10-Pad3_ Net-_C2-Pad2_ Net-_D1-Pad2_ eSim_NPN
Q12  Net-_D1-Pad2_ Net-_Q12-Pad2_ Net-_Q12-Pad3_ eSim_NPN
R7  Net-_Q12-Pad3_ -VEE 150
Q15  -VEE Net-_D1-Pad2_ Net-_Q15-Pad3_ eSim_PNP
R8  OUT Net-_Q15-Pad3_ 27
R9  OUT Net-_Q13-Pad2_ 27
Q13  Net-_Q10-Pad2_ Net-_Q13-Pad2_ OUT eSim_NPN
Q14  +VCC Net-_Q10-Pad3_ Net-_Q13-Pad2_ eSim_NPN
Q16  Net-_Q16-Pad1_ Net-_Q16-Pad1_ +VCC eSim_PNP
Q17  Net-_Q16-Pad1_ +VCC Net-_Q17-Pad3_ eSim_NPN
R10  Net-_Q17-Pad3_ -VEE 1k
U2  -VEE +VCC zener
J1  +VCC -VEE -VEE jfet_n

.end
