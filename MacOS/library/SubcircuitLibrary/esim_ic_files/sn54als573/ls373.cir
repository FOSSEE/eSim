* C:\Users\Shanthipriya\Desktop\madeeasy\FOSSEE\eSim\library\SubcircuitLibrary\ls373\ls373.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 05/12/25 07:42:26

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
X1  Net-_U1-Pad3_ Net-_U2-Pad2_ ? Net-_U3-Pad2_ d_l
X2  Net-_U1-Pad4_ Net-_U2-Pad2_ ? Net-_U4-Pad2_ d_l
X3  Net-_U1-Pad5_ Net-_U2-Pad2_ ? Net-_U5-Pad2_ d_l
X4  Net-_U1-Pad6_ Net-_U2-Pad2_ ? Net-_U6-Pad2_ d_l
X5  Net-_U1-Pad7_ Net-_U2-Pad2_ ? Net-_U7-Pad2_ d_l
X6  Net-_U1-Pad8_ Net-_U2-Pad2_ ? Net-_U8-Pad2_ d_l
X7  Net-_U1-Pad9_ Net-_U2-Pad2_ ? Net-_U9-Pad2_ d_l
X8  Net-_U1-Pad10_ Net-_U2-Pad2_ ? Net-_U10-Pad2_ d_l
U2  Net-_U1-Pad1_ Net-_U2-Pad2_ d_inverter
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ Net-_U1-Pad16_ Net-_U1-Pad17_ Net-_U1-Pad18_ PORT
U3  Net-_U1-Pad2_ Net-_U3-Pad2_ Net-_U1-Pad11_ d_and
U4  Net-_U1-Pad2_ Net-_U4-Pad2_ Net-_U1-Pad12_ d_and
U5  Net-_U1-Pad2_ Net-_U5-Pad2_ Net-_U1-Pad13_ d_and
U6  Net-_U1-Pad2_ Net-_U6-Pad2_ Net-_U1-Pad14_ d_and
U7  Net-_U1-Pad2_ Net-_U7-Pad2_ Net-_U1-Pad15_ d_and
U8  Net-_U1-Pad2_ Net-_U8-Pad2_ Net-_U1-Pad16_ d_and
U9  Net-_U1-Pad2_ Net-_U9-Pad2_ Net-_U1-Pad17_ d_and
U10  Net-_U1-Pad2_ Net-_U10-Pad2_ Net-_U1-Pad18_ d_and

.end
