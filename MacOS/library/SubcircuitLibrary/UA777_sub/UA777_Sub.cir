* C:\FOSSEE\eSim\library\SubcircuitLibrary\UA777_Sub\UA777_Sub.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 07/07/24 22:52:52

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
Q2  Net-_Q1-Pad1_ Net-_Q1-Pad1_ Net-_Q12-Pad3_ eSim_PNP
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
Q3  Net-_Q3-Pad1_ Net-_Q10-Pad1_ Net-_Q1-Pad3_ eSim_PNP
Q6  Net-_Q6-Pad1_ Net-_Q10-Pad1_ Net-_Q6-Pad3_ eSim_PNP
Q8  Net-_Q1-Pad1_ Net-_Q8-Pad2_ Net-_Q6-Pad3_ eSim_NPN
Q5  Net-_Q12-Pad3_ Net-_Q3-Pad1_ Net-_Q4-Pad2_ eSim_NPN
Q4  Net-_Q3-Pad1_ Net-_Q4-Pad2_ Net-_Q4-Pad3_ eSim_NPN
Q7  Net-_Q6-Pad1_ Net-_Q4-Pad2_ Net-_Q7-Pad3_ eSim_NPN
R2  Net-_Q4-Pad3_ Net-_Q11-Pad3_ 1k
R3  Net-_Q4-Pad2_ Net-_Q11-Pad3_ 50k
R4  Net-_Q7-Pad3_ Net-_Q11-Pad3_ 1k
Q9  Net-_Q10-Pad1_ Net-_Q1-Pad1_ Net-_Q12-Pad3_ eSim_PNP
R5  Net-_Q13-Pad1_ Net-_Q6-Pad1_ 300
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
R6  Net-_Q10-Pad3_ Net-_Q11-Pad3_ 10k
Q12  Net-_Q12-Pad1_ Net-_Q12-Pad1_ Net-_Q12-Pad3_ eSim_PNP
R7  Net-_Q10-Pad2_ Net-_Q12-Pad1_ 40k
Q11  Net-_Q10-Pad2_ Net-_Q10-Pad2_ Net-_Q11-Pad3_ eSim_NPN
Q15  Net-_Q15-Pad1_ Net-_Q12-Pad1_ Net-_Q12-Pad3_ eSim_PNP
Q17  Net-_Q17-Pad1_ Net-_Q12-Pad1_ Net-_Q12-Pad3_ eSim_PNP
Q14  Net-_Q12-Pad3_ Net-_Q13-Pad1_ Net-_Q14-Pad3_ eSim_NPN
Q16  Net-_Q15-Pad1_ Net-_Q14-Pad3_ Net-_Q16-Pad3_ eSim_NPN
R10  Net-_Q11-Pad3_ Net-_Q16-Pad3_ 100
Q13  Net-_Q13-Pad1_ Net-_Q13-Pad2_ Net-_Q11-Pad3_ eSim_NPN
R9  Net-_Q11-Pad3_ Net-_Q14-Pad3_ 50k
Q25  Net-_Q12-Pad3_ Net-_Q17-Pad1_ Net-_Q23-Pad2_ eSim_NPN
Q23  Net-_Q17-Pad1_ Net-_Q23-Pad2_ Net-_Q23-Pad3_ eSim_NPN
Q19  Net-_Q17-Pad1_ Net-_Q17-Pad1_ Net-_Q19-Pad3_ eSim_NPN
Q21  Net-_Q17-Pad1_ Net-_Q19-Pad3_ Net-_Q21-Pad3_ eSim_NPN
R11  Net-_Q19-Pad3_ Net-_Q21-Pad3_ 50k
Q22  Net-_Q11-Pad3_ Net-_Q15-Pad1_ Net-_Q21-Pad3_ eSim_PNP
Q20  Net-_Q11-Pad3_ Net-_Q15-Pad1_ Net-_Q13-Pad1_ eSim_PNP
Q18  Net-_Q13-Pad2_ Net-_Q13-Pad2_ Net-_Q11-Pad3_ eSim_NPN
Q24  Net-_Q13-Pad2_ Net-_Q24-Pad2_ Net-_Q23-Pad3_ eSim_PNP
Q26  Net-_Q11-Pad3_ Net-_Q21-Pad3_ Net-_Q24-Pad2_ eSim_PNP
R12  Net-_Q11-Pad3_ Net-_Q13-Pad2_ 50k
R13  Net-_Q23-Pad2_ Net-_Q23-Pad3_ 27
R14  Net-_Q23-Pad3_ Net-_Q24-Pad2_ 22
R1  Net-_Q8-Pad2_ Net-_R1-Pad2_ 1k
R8  Net-_Q8-Pad2_ Net-_Q23-Pad3_ 4k
U1  Net-_Q6-Pad1_ Net-_R1-Pad2_ Net-_Q1-Pad2_ Net-_Q11-Pad3_ Net-_Q3-Pad1_ Net-_Q23-Pad3_ Net-_Q12-Pad3_ Net-_Q15-Pad1_ PORT

.end
