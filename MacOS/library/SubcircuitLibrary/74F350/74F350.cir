* C:\FOSSEE_mains\FOSSEE\eSim\library\SubcircuitLibrary\74F350\74F350.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 02/05/25 19:58:19

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
X16  Net-_U24-Pad2_ Net-_U22-Pad2_ Net-_U1-Pad7_ Net-_U16-Pad1_ 3_and
X15  Net-_U25-Pad2_ Net-_U22-Pad2_ Net-_U1-Pad6_ Net-_U16-Pad2_ 3_and
X14  Net-_U24-Pad2_ Net-_U23-Pad2_ Net-_U1-Pad5_ Net-_U13-Pad1_ 3_and
X13  Net-_U25-Pad2_ Net-_U23-Pad2_ Net-_U1-Pad4_ Net-_U13-Pad2_ 3_and
X12  Net-_U24-Pad2_ Net-_U22-Pad2_ Net-_U1-Pad6_ Net-_U12-Pad1_ 3_and
X11  Net-_U25-Pad2_ Net-_U22-Pad2_ Net-_U1-Pad5_ Net-_U12-Pad2_ 3_and
X10  Net-_U24-Pad2_ Net-_U23-Pad2_ Net-_U1-Pad4_ Net-_U9-Pad1_ 3_and
X9  Net-_U25-Pad2_ Net-_U23-Pad2_ Net-_U1-Pad3_ Net-_U9-Pad2_ 3_and
X8  Net-_U24-Pad2_ Net-_U22-Pad2_ Net-_U1-Pad5_ Net-_U8-Pad1_ 3_and
X7  Net-_U25-Pad2_ Net-_U22-Pad2_ Net-_U1-Pad4_ Net-_U8-Pad2_ 3_and
X6  Net-_U24-Pad2_ Net-_U23-Pad2_ Net-_U1-Pad3_ Net-_U6-Pad1_ 3_and
X5  Net-_U25-Pad2_ Net-_U23-Pad2_ Net-_U1-Pad2_ Net-_U6-Pad2_ 3_and
X4  Net-_U24-Pad2_ Net-_U22-Pad2_ Net-_U1-Pad4_ Net-_U4-Pad1_ 3_and
X3  Net-_U25-Pad2_ Net-_U22-Pad2_ Net-_U1-Pad3_ Net-_U4-Pad2_ 3_and
X2  Net-_U24-Pad2_ Net-_U23-Pad2_ Net-_U1-Pad2_ Net-_U2-Pad1_ 3_and
X1  Net-_U25-Pad2_ Net-_U23-Pad2_ Net-_U1-Pad1_ Net-_U2-Pad2_ 3_and
U26  Net-_U1-Pad13_ Net-_U10-Pad1_ d_inverter
U24  Net-_U1-Pad10_ Net-_U24-Pad2_ d_inverter
U22  Net-_U1-Pad9_ Net-_U22-Pad2_ d_inverter
U25  Net-_U24-Pad2_ Net-_U25-Pad2_ d_inverter
U23  Net-_U22-Pad2_ Net-_U23-Pad2_ d_inverter
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ ? Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ ? PORT
U20  Net-_U10-Pad1_ Net-_U14-Pad3_ Net-_U1-Pad15_ d_and
U15  Net-_U10-Pad1_ Net-_U11-Pad3_ Net-_U1-Pad14_ d_and
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ Net-_U1-Pad12_ d_and
U5  Net-_U10-Pad1_ Net-_U3-Pad3_ Net-_U1-Pad11_ d_and
U14  Net-_U14-Pad1_ Net-_U13-Pad3_ Net-_U14-Pad3_ d_or
U11  Net-_U11-Pad1_ Net-_U11-Pad2_ Net-_U11-Pad3_ d_or
U7  Net-_U7-Pad1_ Net-_U6-Pad3_ Net-_U10-Pad2_ d_or
U3  Net-_U3-Pad1_ Net-_U2-Pad3_ Net-_U3-Pad3_ d_or
U16  Net-_U16-Pad1_ Net-_U16-Pad2_ Net-_U14-Pad1_ d_or
U13  Net-_U13-Pad1_ Net-_U13-Pad2_ Net-_U13-Pad3_ d_or
U12  Net-_U12-Pad1_ Net-_U12-Pad2_ Net-_U11-Pad1_ d_or
U9  Net-_U9-Pad1_ Net-_U9-Pad2_ Net-_U11-Pad2_ d_or
U8  Net-_U8-Pad1_ Net-_U8-Pad2_ Net-_U7-Pad1_ d_or
U6  Net-_U6-Pad1_ Net-_U6-Pad2_ Net-_U6-Pad3_ d_or
U4  Net-_U4-Pad1_ Net-_U4-Pad2_ Net-_U3-Pad1_ d_or
U2  Net-_U2-Pad1_ Net-_U2-Pad2_ Net-_U2-Pad3_ d_or

.end
