* C:\FOSSEE\eSim\library\SubcircuitLibrary\TL071\TL071.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 3/1/2025 11:13:32 AM

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
J1  Net-_J1-Pad1_ vin1 Net-_J1-Pad3_ jfet_p
J2  Net-_J1-Pad1_ vin2 Net-_C1-Pad1_ jfet_p
Q3  Net-_J1-Pad1_ Net-_Q12-Pad2_ Net-_Q3-Pad3_ eSim_PNP
R3  Vcc Net-_Q3-Pad3_ 30R
Q1  Net-_J1-Pad3_ Net-_Q1-Pad2_ N1 eSim_NPN
Q4  Net-_C1-Pad1_ Net-_Q1-Pad2_ N2 eSim_NPN
Q2  Vcc Net-_J1-Pad3_ Net-_Q1-Pad2_ eSim_NPN
Q5  Vcc Net-_C1-Pad1_ Net-_Q5-Pad3_ eSim_NPN
R1  N1 Vee 1kR
R4  N2 Vee 1kR
R2  Net-_Q1-Pad2_ Vee 50kR
R5  Net-_Q5-Pad3_ Vee 50kR
D1  Net-_C1-Pad1_ Net-_C1-Pad2_ eSim_Diode
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 18pF
Q7  Vcc Net-_Q12-Pad2_ Net-_Q10-Pad2_ eSim_PNP
Q12  Vcc Net-_Q12-Pad2_ Net-_Q12-Pad2_ eSim_PNP
Q6  Net-_Q10-Pad2_ Net-_Q10-Pad2_ Net-_Q6-Pad3_ eSim_NPN
Q10  Vcc Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
Q9  Net-_Q10-Pad2_ Net-_Q6-Pad3_ Net-_C1-Pad2_ eSim_NPN
R8  Net-_Q10-Pad3_ Net-_R10-Pad1_ 100R
R9  Net-_R10-Pad1_ Net-_Q11-Pad1_ 100R
Q11  Net-_Q11-Pad1_ Net-_C1-Pad2_ Vee eSim_PNP
Q8  Net-_C1-Pad2_ Net-_Q5-Pad3_ Net-_Q8-Pad3_ eSim_NPN
R7  Net-_Q8-Pad3_ Vee 100R
Q13  Net-_Q12-Pad2_ Net-_J3-Pad3_ Net-_Q13-Pad3_ eSim_NPN
R11  Net-_Q13-Pad3_ Vee 5kR
U1  Vee Net-_J3-Pad3_ zener
J3  Vcc Vcc Net-_J3-Pad3_ jfet_p
R10  Net-_R10-Pad1_ vout 200R
R6  Net-_Q6-Pad3_ Net-_C1-Pad2_ 100R

.end
