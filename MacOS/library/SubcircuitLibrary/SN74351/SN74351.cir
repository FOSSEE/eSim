* C:\FOSSEE_mains\FOSSEE\eSim\library\SubcircuitLibrary\SN74351\SN74351.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 02/05/25 22:36:17

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
X1  Net-_U1-Pad6_ Net-_U2-Pad2_ Net-_U3-Pad2_ Net-_U4-Pad2_ Net-_U20-Pad1_ Net-_U6-Pad1_ 5_and
X2  Net-_U1-Pad7_ Net-_U1-Pad3_ Net-_U3-Pad2_ Net-_U4-Pad2_ Net-_U20-Pad1_ Net-_U6-Pad2_ 5_and
X3  Net-_U1-Pad8_ Net-_U2-Pad2_ Net-_U1-Pad4_ Net-_U4-Pad2_ Net-_U20-Pad1_ Net-_U7-Pad1_ 5_and
X4  Net-_U1-Pad9_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U4-Pad2_ Net-_U20-Pad1_ Net-_U7-Pad2_ 5_and
X5  Net-_U1-Pad14_ Net-_U2-Pad2_ Net-_U3-Pad2_ Net-_U1-Pad5_ Net-_U20-Pad1_ Net-_U9-Pad1_ 5_and
X6  Net-_U1-Pad13_ Net-_U1-Pad3_ Net-_U3-Pad2_ Net-_U1-Pad5_ Net-_U20-Pad1_ Net-_U9-Pad2_ 5_and
X7  Net-_U1-Pad12_ Net-_U2-Pad2_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U20-Pad1_ Net-_U11-Pad1_ 5_and
X8  Net-_U1-Pad11_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U20-Pad1_ Net-_U11-Pad2_ 5_and
X9  Net-_U20-Pad1_ Net-_U1-Pad5_ Net-_U1-Pad4_ Net-_U1-Pad3_ Net-_U1-Pad11_ Net-_U8-Pad1_ 5_and
X10  Net-_U20-Pad1_ Net-_U1-Pad5_ Net-_U1-Pad4_ Net-_U2-Pad2_ Net-_U1-Pad12_ Net-_U8-Pad2_ 5_and
X11  Net-_U20-Pad1_ Net-_U1-Pad5_ Net-_U3-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad13_ Net-_U10-Pad1_ 5_and
X12  Net-_U20-Pad1_ Net-_U1-Pad5_ Net-_U3-Pad2_ Net-_U2-Pad2_ Net-_U1-Pad14_ Net-_U10-Pad2_ 5_and
X13  Net-_U20-Pad1_ Net-_U4-Pad2_ Net-_U1-Pad4_ Net-_U1-Pad3_ Net-_U1-Pad15_ Net-_U12-Pad1_ 5_and
X14  Net-_U20-Pad1_ Net-_U2-Pad2_ Net-_U4-Pad2_ Net-_U1-Pad4_ Net-_U1-Pad16_ Net-_U12-Pad2_ 5_and
X15  Net-_U20-Pad1_ Net-_U4-Pad2_ Net-_U3-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad17_ Net-_U13-Pad1_ 5_and
X16  Net-_U20-Pad1_ Net-_U4-Pad2_ Net-_U2-Pad2_ Net-_U3-Pad2_ Net-_U1-Pad18_ Net-_U13-Pad2_ 5_and
U5  Net-_U1-Pad2_ Net-_U20-Pad1_ d_inverter
U2  Net-_U1-Pad3_ Net-_U2-Pad2_ d_inverter
U3  Net-_U1-Pad4_ Net-_U3-Pad2_ d_inverter
U4  Net-_U1-Pad5_ Net-_U4-Pad2_ d_inverter
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ ? Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ Net-_U1-Pad16_ Net-_U1-Pad17_ Net-_U1-Pad18_ Net-_U1-Pad19_ ? PORT
U20  Net-_U20-Pad1_ Net-_U20-Pad2_ Net-_U1-Pad1_ d_and
U21  Net-_U20-Pad1_ Net-_U21-Pad2_ Net-_U1-Pad19_ d_and
U18  Net-_U14-Pad3_ Net-_U16-Pad3_ Net-_U18-Pad3_ d_or
U14  Net-_U14-Pad1_ Net-_U14-Pad2_ Net-_U14-Pad3_ d_or
U16  Net-_U16-Pad1_ Net-_U11-Pad3_ Net-_U16-Pad3_ d_or
U11  Net-_U11-Pad1_ Net-_U11-Pad2_ Net-_U11-Pad3_ d_or
U9  Net-_U9-Pad1_ Net-_U9-Pad2_ Net-_U16-Pad1_ d_or
U7  Net-_U7-Pad1_ Net-_U7-Pad2_ Net-_U14-Pad2_ d_or
U6  Net-_U6-Pad1_ Net-_U6-Pad2_ Net-_U14-Pad1_ d_or
U19  Net-_U15-Pad3_ Net-_U17-Pad3_ Net-_U19-Pad3_ d_or
U17  Net-_U12-Pad3_ Net-_U13-Pad3_ Net-_U17-Pad3_ d_or
U15  Net-_U15-Pad1_ Net-_U10-Pad3_ Net-_U15-Pad3_ d_or
U8  Net-_U8-Pad1_ Net-_U8-Pad2_ Net-_U15-Pad1_ d_or
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ Net-_U10-Pad3_ d_or
U12  Net-_U12-Pad1_ Net-_U12-Pad2_ Net-_U12-Pad3_ d_or
U13  Net-_U13-Pad1_ Net-_U13-Pad2_ Net-_U13-Pad3_ d_or
U22  Net-_U18-Pad3_ Net-_U20-Pad2_ d_inverter
U23  Net-_U19-Pad3_ Net-_U21-Pad2_ d_inverter

.end
