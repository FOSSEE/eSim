* C:\FOSSEE\eSim\library\SubcircuitLibrary\SN74LV3T97_EP\SN74LV3T97_EP.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 05/18/24 13:38:01

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
M6  Net-_M11-Pad3_ Net-_M11-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M11  Net-_M10-Pad1_ Net-_M11-Pad2_ Net-_M11-Pad3_ Net-_M10-Pad1_ mosfet_p
M7  Net-_M12-Pad3_ Net-_M12-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M12  Net-_M10-Pad1_ Net-_M12-Pad2_ Net-_M12-Pad3_ Net-_M10-Pad1_ mosfet_p
M2  Net-_M2-Pad1_ Net-_M2-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M8  Net-_M10-Pad1_ Net-_M2-Pad2_ Net-_M2-Pad1_ Net-_M10-Pad1_ mosfet_p
M27  Net-_M27-Pad1_ Net-_M11-Pad3_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M31  Net-_M10-Pad1_ Net-_M11-Pad3_ Net-_M27-Pad1_ Net-_M10-Pad1_ mosfet_p
M23  Net-_M23-Pad1_ Net-_M12-Pad3_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M28  Net-_M10-Pad1_ Net-_M12-Pad3_ Net-_M23-Pad1_ Net-_M10-Pad1_ mosfet_p
M20  Net-_M20-Pad1_ Net-_M2-Pad1_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M24  Net-_M10-Pad1_ Net-_M2-Pad1_ Net-_M20-Pad1_ Net-_M10-Pad1_ mosfet_p
M40  Net-_M10-Pad1_ Net-_M27-Pad1_ Net-_M40-Pad3_ Net-_M10-Pad1_ mosfet_p
M58  Net-_M10-Pad1_ Net-_M20-Pad1_ Net-_M40-Pad3_ Net-_M10-Pad1_ mosfet_p
M49  Net-_M40-Pad3_ Net-_M27-Pad1_ Net-_M49-Pad3_ Net-_M49-Pad3_ mosfet_n
M50  Net-_M49-Pad3_ Net-_M20-Pad1_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M65  Net-_M65-Pad1_ Net-_M40-Pad3_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M68  Net-_M10-Pad1_ Net-_M40-Pad3_ Net-_M65-Pad1_ Net-_M10-Pad1_ mosfet_p
M38  Net-_M10-Pad1_ Net-_M23-Pad1_ Net-_M38-Pad3_ Net-_M10-Pad1_ mosfet_p
M56  Net-_M10-Pad1_ Net-_M2-Pad1_ Net-_M38-Pad3_ Net-_M10-Pad1_ mosfet_p
M45  Net-_M38-Pad3_ Net-_M23-Pad1_ Net-_M45-Pad3_ Net-_M45-Pad3_ mosfet_n
M46  Net-_M45-Pad3_ Net-_M2-Pad1_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M62  Net-_M62-Pad1_ Net-_M38-Pad3_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M66  Net-_M10-Pad1_ Net-_M38-Pad3_ Net-_M62-Pad1_ Net-_M10-Pad1_ mosfet_p
M74  Net-_M74-Pad1_ Net-_M65-Pad1_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M83  Net-_M74-Pad1_ Net-_M62-Pad1_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M78  Net-_M10-Pad1_ Net-_M65-Pad1_ Net-_M78-Pad3_ Net-_M10-Pad1_ mosfet_p
M79  Net-_M78-Pad3_ Net-_M62-Pad1_ Net-_M74-Pad1_ Net-_M78-Pad3_ mosfet_p
M86  Net-_M86-Pad1_ Net-_M74-Pad1_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M88  Net-_M10-Pad1_ Net-_M74-Pad1_ Net-_M86-Pad1_ Net-_M10-Pad1_ mosfet_p
M3  Net-_M25-Pad2_ Net-_M3-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M9  Net-_M10-Pad1_ Net-_M3-Pad2_ Net-_M25-Pad2_ Net-_M10-Pad1_ mosfet_p
M4  Net-_M10-Pad3_ Net-_M10-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M10  Net-_M10-Pad1_ Net-_M10-Pad2_ Net-_M10-Pad3_ Net-_M10-Pad1_ mosfet_p
M1  Net-_M1-Pad1_ Net-_M1-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M5  Net-_M10-Pad1_ Net-_M1-Pad2_ Net-_M1-Pad1_ Net-_M10-Pad1_ mosfet_p
M25  Net-_M25-Pad1_ Net-_M25-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M29  Net-_M10-Pad1_ Net-_M25-Pad2_ Net-_M25-Pad1_ Net-_M10-Pad1_ mosfet_p
M21  Net-_M21-Pad1_ Net-_M10-Pad3_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M26  Net-_M10-Pad1_ Net-_M10-Pad3_ Net-_M21-Pad1_ Net-_M10-Pad1_ mosfet_p
M19  Net-_M19-Pad1_ Net-_M1-Pad1_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M22  Net-_M10-Pad1_ Net-_M1-Pad1_ Net-_M19-Pad1_ Net-_M10-Pad1_ mosfet_p
M39  Net-_M10-Pad1_ Net-_M25-Pad1_ Net-_M39-Pad3_ Net-_M10-Pad1_ mosfet_p
M57  Net-_M10-Pad1_ Net-_M19-Pad1_ Net-_M39-Pad3_ Net-_M10-Pad1_ mosfet_p
M47  Net-_M39-Pad3_ Net-_M25-Pad1_ Net-_M47-Pad3_ Net-_M47-Pad3_ mosfet_n
M48  Net-_M47-Pad3_ Net-_M19-Pad1_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M63  Net-_M63-Pad1_ Net-_M39-Pad3_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M67  Net-_M10-Pad1_ Net-_M39-Pad3_ Net-_M63-Pad1_ Net-_M10-Pad1_ mosfet_p
M37  Net-_M10-Pad1_ Net-_M21-Pad1_ Net-_M37-Pad3_ Net-_M10-Pad1_ mosfet_p
M55  Net-_M10-Pad1_ Net-_M1-Pad1_ Net-_M37-Pad3_ Net-_M10-Pad1_ mosfet_p
M43  Net-_M37-Pad3_ Net-_M21-Pad1_ Net-_M43-Pad3_ Net-_M43-Pad3_ mosfet_n
M44  Net-_M43-Pad3_ Net-_M1-Pad1_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M61  Net-_M61-Pad1_ Net-_M37-Pad3_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M64  Net-_M10-Pad1_ Net-_M37-Pad3_ Net-_M61-Pad1_ Net-_M10-Pad1_ mosfet_p
M73  Net-_M73-Pad1_ Net-_M63-Pad1_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M82  Net-_M73-Pad1_ Net-_M61-Pad1_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M76  Net-_M10-Pad1_ Net-_M63-Pad1_ Net-_M76-Pad3_ Net-_M10-Pad1_ mosfet_p
M77  Net-_M76-Pad3_ Net-_M61-Pad1_ Net-_M73-Pad1_ Net-_M76-Pad3_ mosfet_p
M85  Net-_M85-Pad1_ Net-_M73-Pad1_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M87  Net-_M10-Pad1_ Net-_M73-Pad1_ Net-_M85-Pad1_ Net-_M10-Pad1_ mosfet_p
M14  Net-_M14-Pad1_ Net-_M14-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M17  Net-_M10-Pad1_ Net-_M14-Pad2_ Net-_M14-Pad1_ Net-_M10-Pad1_ mosfet_p
M15  Net-_M15-Pad1_ Net-_M15-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M18  Net-_M10-Pad1_ Net-_M15-Pad2_ Net-_M15-Pad1_ Net-_M10-Pad1_ mosfet_p
M13  Net-_M13-Pad1_ Net-_M13-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M16  Net-_M10-Pad1_ Net-_M13-Pad2_ Net-_M13-Pad1_ Net-_M10-Pad1_ mosfet_p
M34  Net-_M34-Pad1_ Net-_M14-Pad1_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M36  Net-_M10-Pad1_ Net-_M14-Pad1_ Net-_M34-Pad1_ Net-_M10-Pad1_ mosfet_p
M32  Net-_M32-Pad1_ Net-_M15-Pad1_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M35  Net-_M10-Pad1_ Net-_M15-Pad1_ Net-_M32-Pad1_ Net-_M10-Pad1_ mosfet_p
M30  Net-_M30-Pad1_ Net-_M13-Pad1_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M33  Net-_M10-Pad1_ Net-_M13-Pad1_ Net-_M30-Pad1_ Net-_M10-Pad1_ mosfet_p
M42  Net-_M10-Pad1_ Net-_M34-Pad1_ Net-_M42-Pad3_ Net-_M10-Pad1_ mosfet_p
M60  Net-_M10-Pad1_ Net-_M30-Pad1_ Net-_M42-Pad3_ Net-_M10-Pad1_ mosfet_p
M53  Net-_M42-Pad3_ Net-_M34-Pad1_ Net-_M53-Pad3_ Net-_M53-Pad3_ mosfet_n
M54  Net-_M53-Pad3_ Net-_M30-Pad1_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M70  Net-_M70-Pad1_ Net-_M42-Pad3_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M72  Net-_M10-Pad1_ Net-_M42-Pad3_ Net-_M70-Pad1_ Net-_M10-Pad1_ mosfet_p
M41  Net-_M10-Pad1_ Net-_M32-Pad1_ Net-_M41-Pad3_ Net-_M10-Pad1_ mosfet_p
M59  Net-_M10-Pad1_ Net-_M13-Pad1_ Net-_M41-Pad3_ Net-_M10-Pad1_ mosfet_p
M51  Net-_M41-Pad3_ Net-_M32-Pad1_ Net-_M51-Pad3_ Net-_M51-Pad3_ mosfet_n
M52  Net-_M51-Pad3_ Net-_M13-Pad1_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M69  Net-_M69-Pad1_ Net-_M41-Pad3_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M71  Net-_M10-Pad1_ Net-_M41-Pad3_ Net-_M69-Pad1_ Net-_M10-Pad1_ mosfet_p
M75  Net-_M75-Pad1_ Net-_M70-Pad1_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M84  Net-_M75-Pad1_ Net-_M69-Pad1_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M80  Net-_M10-Pad1_ Net-_M70-Pad1_ Net-_M80-Pad3_ Net-_M10-Pad1_ mosfet_p
M81  Net-_M80-Pad3_ Net-_M69-Pad1_ Net-_M75-Pad1_ Net-_M80-Pad3_ mosfet_p
M89  Net-_M89-Pad1_ Net-_M75-Pad1_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_n
M90  Net-_M10-Pad1_ Net-_M75-Pad1_ Net-_M89-Pad1_ Net-_M10-Pad1_ mosfet_p
U1  Net-_M11-Pad2_ Net-_M12-Pad2_ Net-_M3-Pad2_ Net-_M10-Pad2_ Net-_M14-Pad2_ Net-_M15-Pad2_ Net-_M1-Pad3_ Net-_M89-Pad1_ Net-_M13-Pad2_ Net-_M85-Pad1_ Net-_M1-Pad2_ Net-_M86-Pad1_ Net-_M2-Pad2_ Net-_M10-Pad1_ PORT

.end
