* D:\FOSSEE\eSim\library\SubcircuitLibrary\RC4559N_IC\RC4559N_IC.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 07/13/24 18:31:43

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
R3  Net-_J1-Pad3_ Net-_Q3-Pad3_ 8.7k
Q3  Net-_Q1-Pad3_ Net-_Q13-Pad1_ Net-_Q3-Pad3_ eSim_PNP
Q5  Net-_C2-Pad2_ Net-_Q5-Pad2_ Net-_Q1-Pad3_ eSim_PNP
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_PNP
Q2  Net-_Q1-Pad1_ Net-_Q1-Pad1_ Net-_C1-Pad1_ eSim_NPN
Q4  Net-_C2-Pad2_ Net-_Q1-Pad1_ Net-_Q4-Pad3_ eSim_NPN
R2  Net-_C1-Pad1_ Net-_C1-Pad2_ 5k
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 15p
R4  Net-_Q4-Pad3_ Net-_C1-Pad2_ 5k
Q9  Net-_Q10-Pad1_ Net-_Q13-Pad1_ Net-_J1-Pad3_ eSim_PNP
Q13  Net-_Q13-Pad1_ Net-_Q13-Pad1_ Net-_J1-Pad3_ eSim_PNP
Q11  Net-_J1-Pad3_ Net-_Q10-Pad1_ Net-_Q11-Pad3_ eSim_NPN
Q7  Net-_Q10-Pad1_ Net-_Q10-Pad1_ Net-_Q10-Pad2_ eSim_NPN
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_C2-Pad1_ eSim_NPN
R7  Net-_Q10-Pad2_ Net-_C2-Pad1_ 50k
C2  Net-_C2-Pad1_ Net-_C2-Pad2_ 15p
D1  Net-_C2-Pad2_ Net-_C2-Pad1_ eSim_Diode
Q6  Net-_J1-Pad3_ Net-_C2-Pad2_ Net-_Q6-Pad3_ eSim_NPN
R6  Net-_Q6-Pad3_ Net-_C1-Pad2_ 50k
R8  Net-_Q11-Pad3_ Net-_R10-Pad2_ 27
R9  Net-_R10-Pad2_ Net-_Q12-Pad3_ 27
Q12  Net-_C1-Pad2_ Net-_C2-Pad1_ Net-_Q12-Pad3_ eSim_PNP
Q8  Net-_C2-Pad1_ Net-_Q6-Pad3_ Net-_C1-Pad2_ eSim_NPN
Q14  Net-_Q13-Pad1_ Net-_J1-Pad1_ Net-_Q14-Pad3_ eSim_NPN
R11  Net-_Q14-Pad3_ Net-_C1-Pad2_ 5.8k
J1  Net-_J1-Pad1_ Net-_C1-Pad2_ Net-_J1-Pad3_ jfet_n
U2  Net-_C1-Pad2_ Net-_J1-Pad1_ zener
R10  Net-_R10-Pad1_ Net-_R10-Pad2_ 120
R14  Net-_J1-Pad3_ Net-_Q17-Pad3_ 8.7k
Q17  Net-_Q15-Pad3_ Net-_Q17-Pad2_ Net-_Q17-Pad3_ eSim_PNP
Q19  Net-_C4-Pad2_ Net-_Q19-Pad2_ Net-_Q15-Pad3_ eSim_PNP
Q15  Net-_Q15-Pad1_ Net-_Q15-Pad2_ Net-_Q15-Pad3_ eSim_PNP
Q16  Net-_Q15-Pad1_ Net-_Q15-Pad1_ Net-_C3-Pad1_ eSim_NPN
Q18  Net-_C4-Pad2_ Net-_Q15-Pad1_ Net-_Q18-Pad3_ eSim_NPN
R13  Net-_C3-Pad1_ Net-_C1-Pad2_ 5k
C3  Net-_C3-Pad1_ Net-_C1-Pad2_ 15p
R15  Net-_Q18-Pad3_ Net-_C1-Pad2_ 5k
Q23  Net-_Q21-Pad1_ Net-_Q17-Pad2_ Net-_J1-Pad3_ eSim_PNP
Q27  Net-_Q17-Pad2_ Net-_Q17-Pad2_ Net-_J1-Pad3_ eSim_PNP
Q25  Net-_J1-Pad3_ Net-_Q21-Pad1_ Net-_Q25-Pad3_ eSim_NPN
Q21  Net-_Q21-Pad1_ Net-_Q21-Pad1_ Net-_Q21-Pad3_ eSim_NPN
Q24  Net-_Q21-Pad1_ Net-_Q21-Pad3_ Net-_C4-Pad1_ eSim_NPN
R18  Net-_Q21-Pad3_ Net-_C4-Pad1_ 50k
C4  Net-_C4-Pad1_ Net-_C4-Pad2_ 15p
D2  Net-_C4-Pad2_ Net-_C4-Pad1_ eSim_Diode
Q20  Net-_J1-Pad3_ Net-_C4-Pad2_ Net-_Q20-Pad3_ eSim_NPN
R16  Net-_Q20-Pad3_ Net-_C1-Pad2_ 50k
R19  Net-_Q25-Pad3_ Net-_R19-Pad2_ 27
R20  Net-_R19-Pad2_ Net-_Q26-Pad3_ 27
Q26  Net-_C1-Pad2_ Net-_C4-Pad1_ Net-_Q26-Pad3_ eSim_PNP
Q22  Net-_C4-Pad1_ Net-_Q20-Pad3_ Net-_C1-Pad2_ eSim_NPN
Q28  Net-_Q17-Pad2_ Net-_J2-Pad1_ Net-_Q28-Pad3_ eSim_NPN
R22  Net-_Q28-Pad3_ Net-_C1-Pad2_ 5.8k
J2  Net-_J2-Pad1_ Net-_C1-Pad2_ Net-_J1-Pad3_ jfet_n
U3  Net-_C1-Pad2_ Net-_J2-Pad1_ zener
R21  Net-_R21-Pad1_ Net-_R19-Pad2_ 120
U1  Net-_R10-Pad1_ Net-_Q1-Pad2_ Net-_Q5-Pad2_ Net-_C1-Pad2_ Net-_Q19-Pad2_ Net-_Q15-Pad2_ Net-_R21-Pad1_ Net-_J1-Pad3_ PORT

.end
