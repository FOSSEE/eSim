* C:\FOSSEE\eSim\library\SubcircuitLibrary\LM4250_Sub\LM4250_Sub.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 07/14/24 16:48:29

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
R3  Net-_Q17-Pad1_ Net-_Q1-Pad3_ 290
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad1_ Net-_Q1-Pad3_ eSim_PNP
R8  Net-_Q17-Pad1_ Net-_Q4-Pad3_ 5k
Q4  Net-_Q4-Pad1_ Net-_Q1-Pad1_ Net-_Q4-Pad3_ eSim_PNP
R7  Net-_R15-Pad1_ Net-_Q17-Pad1_ 100
R9  Net-_Q4-Pad1_ Net-_Q6-Pad3_ 1k
R4  Net-_Q4-Pad1_ Net-_Q2-Pad3_ 5.9k
Q2  Net-_Q2-Pad1_ Net-_Q2-Pad2_ Net-_Q2-Pad3_ eSim_PNP
Q6  Net-_C1-Pad1_ Net-_Q6-Pad2_ Net-_Q6-Pad3_ eSim_PNP
Q3  Net-_Q2-Pad1_ Net-_Q2-Pad1_ Net-_Q3-Pad3_ eSim_NPN
Q5  Net-_C1-Pad1_ Net-_Q2-Pad1_ Net-_Q5-Pad3_ eSim_NPN
R10  Net-_Q5-Pad3_ Net-_Q14-Pad3_ 5k
R5  Net-_Q3-Pad3_ Net-_Q14-Pad3_ 5k
Q7  Net-_Q14-Pad3_ Net-_C1-Pad1_ Net-_Q10-Pad1_ eSim_PNP
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad1_ Net-_Q10-Pad3_ eSim_NPN
Q8  Net-_Q10-Pad3_ Net-_Q2-Pad1_ Net-_Q8-Pad3_ eSim_NPN
R12  Net-_Q8-Pad3_ Net-_Q14-Pad3_ 690
Q9  Net-_Q10-Pad1_ Net-_Q1-Pad1_ Net-_Q9-Pad3_ eSim_PNP
R13  Net-_Q17-Pad1_ Net-_Q9-Pad3_ 5k
Q11  Net-_Q11-Pad1_ Net-_Q1-Pad1_ Net-_Q11-Pad3_ eSim_PNP
R15  Net-_R15-Pad1_ Net-_Q11-Pad3_ 45
Q12  Net-_Q11-Pad1_ Net-_Q11-Pad1_ Net-_Q12-Pad3_ eSim_NPN
Q13  Net-_Q12-Pad3_ Net-_Q12-Pad3_ Net-_C1-Pad2_ eSim_NPN
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 30pF
Q14  Net-_C1-Pad2_ Net-_Q10-Pad3_ Net-_Q14-Pad3_ eSim_NPN
Q17  Net-_Q17-Pad1_ Net-_Q11-Pad1_ Net-_Q15-Pad2_ eSim_NPN
Q15  Net-_Q11-Pad1_ Net-_Q15-Pad2_ Net-_Q15-Pad3_ eSim_NPN
R16  Net-_Q15-Pad2_ Net-_Q15-Pad3_ 10
R17  Net-_Q15-Pad3_ Net-_R17-Pad2_ 100
R20  Net-_R14-Pad1_ Net-_R17-Pad2_ 100
R2  Net-_Q2-Pad2_ Net-_R2-Pad2_ 1k
R14  Net-_R14-Pad1_ Net-_Q2-Pad2_ 6k
R18  Net-_R17-Pad2_ Net-_Q16-Pad3_ 50
R19  Net-_Q16-Pad3_ Net-_Q16-Pad2_ 100
Q16  Net-_C1-Pad2_ Net-_Q16-Pad2_ Net-_Q16-Pad3_ eSim_PNP
Q18  Net-_Q14-Pad3_ Net-_C1-Pad2_ Net-_Q16-Pad2_ eSim_PNP
U1  Net-_Q3-Pad3_ Net-_R2-Pad2_ Net-_Q6-Pad2_ Net-_Q14-Pad3_ Net-_Q5-Pad3_ Net-_R14-Pad1_ Net-_R15-Pad1_ PORT
U2  Net-_Q1-Pad1_ PORT

.end
