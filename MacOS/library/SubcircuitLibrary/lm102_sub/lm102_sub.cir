* C:\FOSSEE\eSim\library\SubcircuitLibrary\lm102_sub\lm102_sub.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 30/05/2024 11:41:12 AM

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad1_ Net-_Q1-Pad3_ eSim_NPN
Q5  Net-_C1-Pad1_ Net-_Q10-Pad2_ Net-_Q5-Pad3_ eSim_NPN
Q2  Net-_Q15-Pad2_ Net-_Q1-Pad1_ Net-_Q10-Pad2_ eSim_PNP
R5  Net-_Q1-Pad3_ Net-_Q5-Pad3_ 6k
R12  Net-_Q1-Pad3_ Net-_Q10-Pad3_ 3k
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
Q15  Net-_Q12-Pad1_ Net-_Q15-Pad2_ Net-_Q15-Pad3_ eSim_NPN
R15  Net-_Q1-Pad3_ Net-_Q15-Pad3_ 270
Q12  Net-_Q12-Pad1_ Net-_Q12-Pad1_ Net-_D1-Pad1_ eSim_NPN
Q13  Net-_Q13-Pad1_ Net-_Q13-Pad1_ Net-_Q10-Pad1_ eSim_NPN
Q9  Net-_D1-Pad2_ Net-_Q8-Pad3_ Net-_Q11-Pad3_ eSim_NPN
Q11  Net-_Q11-Pad1_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_NPN
Q8  Net-_D1-Pad2_ Net-_D1-Pad1_ Net-_Q8-Pad3_ eSim_NPN
Q14  Net-_Q11-Pad1_ Net-_C2-Pad2_ Net-_Q11-Pad2_ eSim_NPN
R10  Net-_Q13-Pad1_ Net-_Q8-Pad3_ 80k
R13  Net-_Q13-Pad1_ Net-_Q11-Pad2_ 80k
R14  Net-_C2-Pad2_ Net-_Q12-Pad1_ 3k
R17  Net-_Q12-Pad1_ Net-_D1-Pad2_ 250
R16  Net-_D1-Pad2_ Net-_Q16-Pad2_ 4k
Q16  Net-_C2-Pad1_ Net-_Q16-Pad2_ Net-_Q11-Pad1_ eSim_NPN
Q18  Net-_Q18-Pad1_ Net-_C2-Pad1_ Net-_Q16-Pad2_ eSim_NPN
Q19  Net-_Q18-Pad1_ Net-_Q16-Pad2_ Net-_D1-Pad2_ eSim_NPN
Q17  Net-_C2-Pad1_ Net-_D1-Pad2_ Net-_Q12-Pad1_ eSim_NPN
C2  Net-_C2-Pad1_ Net-_C2-Pad2_ 20pF
Q6  Net-_C1-Pad1_ Net-_Q6-Pad2_ Net-_Q6-Pad3_ eSim_PNP
Q7  Net-_C2-Pad1_ Net-_Q6-Pad2_ Net-_Q7-Pad3_ eSim_PNP
R3  Net-_R3-Pad1_ Net-_Q18-Pad1_ 500
R8  Net-_R8-Pad1_ Net-_Q18-Pad1_ 500
R9  Net-_Q7-Pad3_ Net-_R8-Pad1_ 1k
D1  Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
R4  Net-_Q6-Pad3_ Net-_R3-Pad1_ 1k
R11  Net-_Q10-Pad1_ Net-_Q11-Pad3_ 200
R1  Net-_Q10-Pad2_ Net-_Q3-Pad3_ 10K
U2  Net-_U2-PadIN_ Net-_Q6-Pad2_ zener
U3  Net-_C1-Pad2_ Net-_U2-PadIN_ zener
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 10pF
R6  Net-_Q3-Pad3_ Net-_C1-Pad2_ 2k
Q4  Net-_Q18-Pad1_ Net-_C1-Pad1_ Net-_Q3-Pad2_ eSim_NPN
Q3  Net-_Q18-Pad1_ Net-_Q3-Pad2_ Net-_Q3-Pad3_ eSim_NPN
R2  Net-_Q3-Pad3_ Net-_Q3-Pad2_ 4k
U1  Net-_R3-Pad1_ Net-_R8-Pad1_ Net-_D1-Pad1_ Net-_Q1-Pad3_ Net-_Q15-Pad3_ Net-_Q12-Pad1_ Net-_Q18-Pad1_ PORT

.end
