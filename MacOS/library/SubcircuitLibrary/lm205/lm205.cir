* D:\FOSSEE\eSim\library\SubcircuitLibrary\lm205\lm205.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 02/18/25 19:55:06

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_PNP
Q4  Net-_Q4-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_PNP
Q7  Net-_Q7-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_PNP
R1  Net-_Q1-Pad2_ Net-_Q4-Pad1_ 2.8k
R2  Net-_Q1-Pad3_ Net-_Q6-Pad1_ 600
R3  Net-_Q2-Pad3_ Net-_Q10-Pad2_ 1.86k
R4  Net-_Q6-Pad3_ Net-_Q10-Pad2_ 1.32k
R6  Net-_Q11-Pad3_ Net-_Q17-Pad2_ 3k
R7  Net-_Q17-Pad2_ Net-_Q16-Pad3_ 6.8k
R8  Net-_Q16-Pad3_ Net-_Q20-Pad1_ 3k
Q3  Net-_Q1-Pad2_ Net-_Q1-Pad2_ Net-_J1-Pad1_ eSim_NPN
Q9  Net-_Q4-Pad1_ Net-_Q7-Pad1_ Net-_Q11-Pad2_ eSim_NPN
Q14  Net-_Q11-Pad2_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_NPN
U2  Net-_C1-Pad2_ Net-_Q7-Pad1_ zener
Q5  Net-_Q1-Pad3_ Net-_Q4-Pad1_ Net-_J1-Pad1_ eSim_NPN
Q11  Net-_J1-Pad1_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_NPN
Q12  Net-_J1-Pad1_ Net-_Q11-Pad2_ Net-_Q12-Pad3_ eSim_NPN
Q17  Net-_Q12-Pad3_ Net-_Q17-Pad2_ Net-_Q15-Pad3_ eSim_NPN
Q19  Net-_C1-Pad1_ Net-_Q16-Pad3_ Net-_Q18-Pad3_ eSim_NPN
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 5p
R9  Net-_Q18-Pad3_ Net-_C1-Pad2_ 2.2k
Q20  Net-_Q20-Pad1_ Net-_Q20-Pad1_ Net-_C1-Pad2_ eSim_NPN
J1  Net-_J1-Pad1_ Net-_C1-Pad2_ Net-_C1-Pad2_ jfet_n
Q2  Net-_Q1-Pad3_ Net-_Q1-Pad1_ Net-_Q2-Pad3_ eSim_NPN
Q10  Net-_Q1-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
Q15  Net-_Q13-Pad3_ Net-_C1-Pad1_ Net-_Q15-Pad3_ eSim_NPN
Q18  Net-_Q15-Pad3_ Net-_Q16-Pad2_ Net-_Q18-Pad3_ eSim_NPN
R5  Net-_Q8-Pad3_ Net-_C1-Pad1_ 4.4k
Q6  Net-_Q6-Pad1_ Net-_Q2-Pad3_ Net-_Q6-Pad3_ eSim_NPN
Q13  Net-_Q1-Pad1_ Net-_Q1-Pad1_ Net-_Q13-Pad3_ eSim_NPN
U1  Net-_Q1-Pad3_ Net-_Q6-Pad1_ Net-_Q6-Pad3_ Net-_Q10-Pad3_ Net-_Q13-Pad3_ Net-_Q16-Pad2_ Net-_Q16-Pad3_ Net-_C1-Pad2_ PORT
Q8  Net-_J1-Pad1_ Net-_Q11-Pad2_ Net-_Q8-Pad3_ eSim_NPN
Q16  Net-_Q13-Pad3_ Net-_Q16-Pad2_ Net-_Q16-Pad3_ eSim_NPN

.end
