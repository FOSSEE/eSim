* C:\FOSSEE\eSim\library\SubcircuitLibrary\MPY_100\MPY_100.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/11/24 14:09:34

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
Q1  Net-_D1-Pad2_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
Q2  Net-_D2-Pad2_ Net-_Q2-Pad2_ Net-_Q2-Pad3_ eSim_NPN
Q4  Net-_Q3-Pad3_ Net-_Q4-Pad2_ Net-_Q4-Pad3_ eSim_NPN
Q6  Net-_Q6-Pad1_ Net-_Q6-Pad2_ Net-_Q6-Pad3_ eSim_NPN
Q9  Net-_Q5-Pad1_ Net-_Q9-Pad2_ Net-_Q9-Pad3_ eSim_NPN
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
D1  Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
D2  Net-_D1-Pad1_ Net-_D2-Pad2_ eSim_Diode
Q3  Net-_Q10-Pad1_ Net-_D2-Pad2_ Net-_Q3-Pad3_ eSim_NPN
Q5  Net-_Q5-Pad1_ Net-_D1-Pad2_ Net-_Q3-Pad3_ eSim_NPN
Q7  Net-_Q10-Pad1_ Net-_D1-Pad2_ Net-_Q6-Pad1_ eSim_NPN
Q8  Net-_Q5-Pad1_ Net-_D2-Pad2_ Net-_Q6-Pad1_ eSim_NPN
U1  Net-_R12-Pad1_ Net-_U1-Pad2_ Net-_I1-Pad2_ Net-_Q1-Pad2_ Net-_Q2-Pad2_ Net-_R8-Pad1_ Net-_R9-Pad2_ Net-_Q4-Pad2_ Net-_Q6-Pad2_ Net-_R2-Pad1_ PORT
R1  Net-_Q1-Pad3_ Net-_I1-Pad1_ 25k
R3  Net-_Q2-Pad3_ Net-_I1-Pad1_ 25k
R5  Net-_Q4-Pad3_ Net-_I2-Pad1_ 25k
R6  Net-_Q6-Pad3_ Net-_I2-Pad1_ 25k
R9  Net-_Q9-Pad2_ Net-_R9-Pad2_ 25k
R10  Net-_Q9-Pad3_ Net-_I3-Pad1_ 25k
R11  Net-_Q10-Pad3_ Net-_I3-Pad1_ 25k
R7  Net-_R2-Pad1_ Net-_Q5-Pad1_ 10k
R4  Net-_R2-Pad1_ Net-_Q10-Pad1_ 10k
R2  Net-_R2-Pad1_ Net-_D1-Pad1_ 10k
R12  Net-_R12-Pad1_ Net-_Q10-Pad2_ 5k
X1  Net-_U1-Pad2_ Net-_Q5-Pad1_ Net-_Q10-Pad1_ Net-_I1-Pad2_ Net-_R2-Pad1_ CA3240-OP
I1  Net-_I1-Pad1_ Net-_I1-Pad2_ dc
I2  Net-_I2-Pad1_ Net-_I1-Pad2_ dc
I3  Net-_I3-Pad1_ Net-_I1-Pad2_ dc
R8  Net-_R8-Pad1_ Net-_Q9-Pad2_ 145k

.end
