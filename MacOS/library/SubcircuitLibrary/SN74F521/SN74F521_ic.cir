* C:\FOSSEE\eSim\library\SubcircuitLibrary\SN74F521_ic\SN74F521_ic.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/06/24 01:25:15

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
X9  Net-_U1-Pad17_ Net-_X8-Pad1_ Net-_U1-Pad20_ Net-_U1-Pad10_ NOT_Gate
X10  Net-_U1-Pad18_ Net-_X10-Pad2_ Net-_U1-Pad20_ Net-_U1-Pad10_ NOT_Gate
X11  Net-_U1-Pad15_ Net-_X1-Pad1_ Net-_U1-Pad20_ Net-_U1-Pad10_ NOT_Gate
X12  Net-_U1-Pad16_ Net-_X1-Pad2_ Net-_U1-Pad20_ Net-_U1-Pad10_ NOT_Gate
X13  Net-_U1-Pad13_ Net-_X13-Pad2_ Net-_U1-Pad20_ Net-_U1-Pad10_ NOT_Gate
X14  Net-_U1-Pad14_ Net-_X14-Pad2_ Net-_U1-Pad20_ Net-_U1-Pad10_ NOT_Gate
X15  Net-_U1-Pad11_ Net-_X15-Pad2_ Net-_U1-Pad20_ Net-_U1-Pad10_ NOT_Gate
X16  Net-_U1-Pad12_ Net-_X16-Pad2_ Net-_U1-Pad20_ Net-_U1-Pad10_ NOT_Gate
X17  Net-_U1-Pad8_ Net-_X17-Pad2_ Net-_U1-Pad20_ Net-_U1-Pad10_ NOT_Gate
X18  Net-_U1-Pad9_ Net-_X18-Pad2_ Net-_U1-Pad20_ Net-_U1-Pad10_ NOT_Gate
X19  Net-_U1-Pad6_ Net-_X19-Pad2_ Net-_U1-Pad20_ Net-_U1-Pad10_ NOT_Gate
X20  Net-_U1-Pad7_ Net-_X20-Pad2_ Net-_U1-Pad20_ Net-_U1-Pad10_ NOT_Gate
X21  Net-_U1-Pad4_ Net-_X21-Pad2_ Net-_U1-Pad20_ Net-_U1-Pad10_ NOT_Gate
X22  Net-_U1-Pad5_ Net-_X22-Pad2_ Net-_U1-Pad20_ Net-_U1-Pad10_ NOT_Gate
X23  Net-_U1-Pad2_ Net-_X23-Pad2_ Net-_U1-Pad20_ Net-_U1-Pad10_ NOT_Gate
X24  Net-_U1-Pad3_ Net-_X24-Pad2_ Net-_U1-Pad20_ Net-_U1-Pad10_ NOT_Gate
X8  Net-_X8-Pad1_ Net-_X10-Pad2_ Net-_X26-Pad1_ Net-_U1-Pad20_ Net-_U1-Pad10_ XNOR_Gate
X1  Net-_X1-Pad1_ Net-_X1-Pad2_ Net-_X1-Pad3_ Net-_U1-Pad20_ Net-_U1-Pad10_ XNOR_Gate
X2  Net-_X13-Pad2_ Net-_X14-Pad2_ Net-_X2-Pad3_ Net-_U1-Pad20_ Net-_U1-Pad10_ XNOR_Gate
X3  Net-_X15-Pad2_ Net-_X16-Pad2_ Net-_X26-Pad4_ Net-_U1-Pad20_ Net-_U1-Pad10_ XNOR_Gate
X4  Net-_X17-Pad2_ Net-_X18-Pad2_ Net-_X26-Pad5_ Net-_U1-Pad20_ Net-_U1-Pad10_ XNOR_Gate
X5  Net-_X19-Pad2_ Net-_X20-Pad2_ Net-_X26-Pad6_ Net-_U1-Pad20_ Net-_U1-Pad10_ XNOR_Gate
X6  Net-_X21-Pad2_ Net-_X22-Pad2_ Net-_X26-Pad7_ Net-_U1-Pad20_ Net-_U1-Pad10_ XNOR_Gate
X7  Net-_X23-Pad2_ Net-_X24-Pad2_ Net-_X26-Pad8_ Net-_U1-Pad20_ Net-_U1-Pad10_ XNOR_Gate
X26  Net-_X26-Pad1_ Net-_X1-Pad3_ Net-_X2-Pad3_ Net-_X26-Pad4_ Net-_X26-Pad5_ Net-_X26-Pad6_ Net-_X26-Pad7_ Net-_X26-Pad8_ Net-_X25-Pad2_ Net-_U1-Pad10_ Net-_U1-Pad20_ Net-_U1-Pad19_ 9_NAND
X25  Net-_U1-Pad1_ Net-_X25-Pad2_ Net-_U1-Pad20_ Net-_U1-Pad10_ NOT_Gate
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ Net-_U1-Pad16_ Net-_U1-Pad17_ Net-_U1-Pad18_ Net-_U1-Pad19_ Net-_U1-Pad20_ PORT

.end
