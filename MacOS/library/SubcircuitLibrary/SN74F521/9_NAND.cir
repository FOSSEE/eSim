* C:\FOSSEE\eSim\library\SubcircuitLibrary\9_NAND\9_NAND.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/05/24 12:34:02

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
M1  Net-_M1-Pad1_ Net-_M1-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad1_ mosfet_p
M2  Net-_M1-Pad1_ Net-_M2-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad1_ mosfet_p
M3  Net-_M1-Pad1_ Net-_M3-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad1_ mosfet_p
M13  Net-_M1-Pad1_ Net-_M13-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad1_ mosfet_p
M14  Net-_M1-Pad1_ Net-_M14-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad1_ mosfet_p
M15  Net-_M1-Pad1_ Net-_M15-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad1_ mosfet_p
M16  Net-_M1-Pad1_ Net-_M10-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad1_ mosfet_p
M17  Net-_M1-Pad1_ Net-_M11-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad1_ mosfet_p
M4  Net-_M1-Pad3_ Net-_M1-Pad2_ Net-_M4-Pad3_ Net-_M4-Pad3_ mosfet_n
M5  Net-_M4-Pad3_ Net-_M2-Pad2_ Net-_M5-Pad3_ Net-_M5-Pad3_ mosfet_n
M6  Net-_M5-Pad3_ Net-_M3-Pad2_ Net-_M6-Pad3_ Net-_M6-Pad3_ mosfet_n
M7  Net-_M6-Pad3_ Net-_M13-Pad2_ Net-_M7-Pad3_ Net-_M7-Pad3_ mosfet_n
M8  Net-_M7-Pad3_ Net-_M14-Pad2_ Net-_M8-Pad3_ Net-_M8-Pad3_ mosfet_n
M9  Net-_M8-Pad3_ Net-_M15-Pad2_ Net-_M10-Pad1_ Net-_M10-Pad1_ mosfet_n
M10  Net-_M10-Pad1_ Net-_M10-Pad2_ Net-_M10-Pad3_ Net-_M10-Pad3_ mosfet_n
M11  Net-_M10-Pad3_ Net-_M11-Pad2_ Net-_M11-Pad3_ Net-_M11-Pad3_ mosfet_n
M12  Net-_M11-Pad3_ Net-_M12-Pad2_ Net-_M12-Pad3_ Net-_M12-Pad3_ mosfet_n
M18  Net-_M1-Pad1_ Net-_M12-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad1_ mosfet_p
U1  Net-_M1-Pad2_ Net-_M2-Pad2_ Net-_M3-Pad2_ Net-_M13-Pad2_ Net-_M14-Pad2_ Net-_M15-Pad2_ Net-_M10-Pad2_ Net-_M11-Pad2_ Net-_M12-Pad2_ Net-_M12-Pad3_ Net-_M1-Pad1_ Net-_M1-Pad3_ PORT

.end
