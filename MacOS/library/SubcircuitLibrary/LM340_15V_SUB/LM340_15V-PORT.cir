* C:\FOSSEE2\eSim\library\SubcircuitLibrary\LM340_15V-PORT\LM340_15V-PORT.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/05/24 11:54:25

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
R1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ 80k
U2  Net-_Q16-Pad3_ Net-_Q1-Pad2_ zener
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
R2  Net-_Q1-Pad3_ Net-_Q3-Pad2_ 7k
R3  Net-_Q3-Pad2_ Net-_Q2-Pad2_ 4.97k
R4  Net-_Q2-Pad2_ Net-_Q16-Pad3_ 830
Q2  Net-_Q12-Pad1_ Net-_Q2-Pad2_ Net-_Q16-Pad3_ eSim_NPN
Q3  Net-_Q3-Pad1_ Net-_Q3-Pad2_ Net-_Q3-Pad3_ eSim_NPN
R5  Net-_Q3-Pad3_ Net-_Q7-Pad3_ 500
Q5  Net-_Q3-Pad1_ Net-_Q1-Pad3_ Net-_Q5-Pad3_ eSim_NPN
Q7  Net-_Q5-Pad3_ Net-_Q13-Pad2_ Net-_Q7-Pad3_ eSim_NPN
Q8  Net-_Q7-Pad3_ Net-_Q8-Pad2_ Net-_C1-Pad2_ eSim_NPN
Q4  Net-_Q3-Pad1_ Net-_Q3-Pad1_ Net-_Q1-Pad1_ eSim_PNP
Q6  Net-_Q12-Pad1_ Net-_Q3-Pad1_ Net-_Q1-Pad1_ eSim_PNP
R6  Net-_C1-Pad2_ Net-_Q16-Pad3_ 1.2k
R7  Net-_Q7-Pad3_ Net-_Q8-Pad2_ 1.9k
R8  Net-_Q8-Pad2_ Net-_C1-Pad1_ 26
Q9  Net-_C1-Pad1_ Net-_C1-Pad2_ Net-_Q16-Pad3_ eSim_NPN
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 4p
Q10  Net-_Q10-Pad1_ Net-_C1-Pad1_ Net-_Q10-Pad3_ eSim_NPN
R9  Net-_Q10-Pad3_ Net-_Q16-Pad3_ 12.1k
Q11  Net-_C2-Pad2_ Net-_Q10-Pad3_ Net-_Q11-Pad3_ eSim_NPN
R12  Net-_Q11-Pad3_ Net-_Q16-Pad3_ 1k
R11  Net-_Q10-Pad1_ Net-_C2-Pad2_ 16.5k
Q13  Net-_Q13-Pad1_ Net-_Q13-Pad2_ Net-_Q10-Pad1_ eSim_NPN
R10  Net-_Q12-Pad3_ Net-_R10-Pad2_ 100
Q12  Net-_Q12-Pad1_ Net-_Q12-Pad2_ Net-_Q12-Pad3_ eSim_NPN
R14  Net-_Q1-Pad1_ Net-_R14-Pad2_ 16k
U3  Net-_Q12-Pad2_ Net-_R14-Pad2_ zener
R15  Net-_Q12-Pad2_ Net-_Q19-Pad3_ 380
Q17  Net-_Q1-Pad1_ Net-_Q12-Pad1_ Net-_Q13-Pad1_ eSim_NPN
Q19  Net-_Q1-Pad1_ Net-_Q13-Pad1_ Net-_Q19-Pad3_ eSim_NPN
R18  Net-_Q13-Pad1_ Net-_Q12-Pad2_ 1.62k
R19  Net-_Q19-Pad3_ Net-_R10-Pad2_ 0.25
R20  Net-_R10-Pad2_ Net-_Q13-Pad2_ 9.67k
Q14  Net-_C2-Pad1_ Net-_C2-Pad2_ Net-_Q14-Pad3_ eSim_NPN
Q15  Net-_Q14-Pad3_ Net-_Q14-Pad3_ Net-_Q15-Pad3_ eSim_NPN
R13  Net-_Q15-Pad3_ Net-_Q16-Pad3_ 4k
C2  Net-_C2-Pad1_ Net-_C2-Pad2_ 20p
Q16  Net-_C2-Pad1_ Net-_Q14-Pad3_ Net-_Q16-Pad3_ eSim_NPN
R17  Net-_Q18-Pad3_ Net-_C2-Pad1_ 4k
R16  Net-_Q12-Pad1_ Net-_Q18-Pad3_ 850
Q18  Net-_Q16-Pad3_ Net-_C2-Pad1_ Net-_Q18-Pad3_ eSim_PNP
R21  Net-_Q13-Pad2_ Net-_Q16-Pad3_ 2.67k
U1  Net-_Q16-Pad3_ Net-_Q1-Pad1_ Net-_R10-Pad2_ PORT

.end
