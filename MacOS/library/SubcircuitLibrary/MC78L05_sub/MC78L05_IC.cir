* D:\FOSSEE\eSim\library\SubcircuitLibrary\MC78L05_IC\MC78L05_IC.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 07/03/24 11:39:31

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
R1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ 15k
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
R2  Net-_Q1-Pad3_ Net-_Q3-Pad2_ 3.8k
R3  Net-_Q3-Pad2_ Net-_Q2-Pad2_ 1.2k
R4  Net-_Q2-Pad2_ Net-_D1-Pad2_ 420
U1  Net-_D1-Pad2_ Net-_Q1-Pad2_ zener
Q4  Net-_Q3-Pad1_ Net-_Q3-Pad1_ Net-_Q1-Pad1_ eSim_PNP
Q7  Net-_Q10-Pad1_ Net-_Q3-Pad1_ Net-_Q1-Pad1_ eSim_PNP
Q3  Net-_Q3-Pad1_ Net-_Q3-Pad2_ Net-_Q3-Pad3_ eSim_NPN
Q6  Net-_Q3-Pad1_ Net-_Q6-Pad2_ Net-_Q3-Pad3_ eSim_NPN
R5  Net-_Q3-Pad3_ Net-_D1-Pad1_ 0.18k
R6  Net-_Q3-Pad3_ Net-_C1-Pad2_ 20k
D1  Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
Q5  Net-_C1-Pad2_ Net-_D1-Pad1_ Net-_Q5-Pad3_ eSim_NPN
R7  Net-_Q5-Pad3_ Net-_D1-Pad2_ 1.0k
R8  Net-_Q10-Pad1_ Net-_C1-Pad1_ 2.2k
Q8  Net-_C1-Pad1_ Net-_C1-Pad2_ Net-_D1-Pad2_ eSim_NPN
Q9  Net-_D1-Pad2_ Net-_C1-Pad1_ Net-_Q10-Pad1_ eSim_PNP
Q11  Net-_Q1-Pad1_ Net-_Q10-Pad1_ Net-_Q11-Pad3_ eSim_NPN
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
Q2  Net-_Q10-Pad1_ Net-_Q2-Pad2_ Net-_D1-Pad2_ eSim_NPN
R9  Net-_Q11-Pad3_ Net-_Q10-Pad3_ 5.0k
Q12  Net-_Q1-Pad1_ Net-_Q11-Pad3_ Net-_Q10-Pad2_ eSim_NPN
R10  Net-_Q10-Pad2_ Net-_Q10-Pad3_ 3.0
R11  Net-_Q10-Pad3_ Net-_Q6-Pad2_ 2.0k
R12  Net-_Q6-Pad2_ Net-_D1-Pad2_ 2.85k
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 5p
U2  Net-_Q10-Pad3_ Net-_D1-Pad2_ Net-_Q1-Pad1_ PORT

.end
