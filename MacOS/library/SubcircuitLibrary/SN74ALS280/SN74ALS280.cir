* C:\FOSSEE\eSim\library\SubcircuitLibrary\SN74ALS280\SN74ALS280.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/15/24 20:41:17

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U13  Net-_U13-Pad1_ Net-_U13-Pad2_ Net-_U13-Pad3_ d_and
U14  Net-_U13-Pad1_ Net-_U14-Pad2_ Net-_U14-Pad3_ d_and
U15  Net-_U14-Pad2_ Net-_U13-Pad2_ Net-_U15-Pad3_ d_and
X19  Net-_U1-Pad3_ Net-_U1-Pad2_ ? Net-_U31-Pad1_ 3_and
U22  Net-_U22-Pad1_ Net-_U13-Pad3_ Net-_U22-Pad3_ d_nand
U23  Net-_U23-Pad1_ Net-_U14-Pad3_ Net-_U23-Pad3_ d_nand
U24  Net-_U24-Pad1_ Net-_U15-Pad3_ Net-_U24-Pad3_ d_nand
X22  Net-_U31-Pad2_ Net-_U22-Pad3_ Net-_U23-Pad3_ Net-_U24-Pad3_ Net-_U34-Pad1_ 4_and
U31  Net-_U31-Pad1_ Net-_U31-Pad2_ d_inverter
U34  Net-_U34-Pad1_ Net-_U34-Pad2_ d_inverter
U35  Net-_U35-Pad1_ Net-_U35-Pad2_ d_inverter
U36  Net-_U36-Pad1_ Net-_U36-Pad2_ d_inverter
X29  Net-_U34-Pad2_ Net-_U35-Pad1_ Net-_U36-Pad1_ Net-_X29-Pad4_ 3_and
X30  Net-_U34-Pad1_ Net-_U35-Pad2_ Net-_U36-Pad1_ Net-_X30-Pad4_ 3_and
X31  Net-_U34-Pad1_ Net-_U36-Pad2_ Net-_U35-Pad1_ Net-_X31-Pad4_ 3_and
X32  Net-_U34-Pad2_ Net-_U36-Pad2_ Net-_U35-Pad2_ Net-_X32-Pad4_ 3_and
X34  Net-_X29-Pad4_ Net-_X30-Pad4_ Net-_X31-Pad4_ Net-_X32-Pad4_ Net-_U38-Pad1_ 4_OR
U38  Net-_U38-Pad1_ Net-_U1-Pad10_ d_inverter
X25  Net-_U34-Pad1_ Net-_U36-Pad2_ Net-_U35-Pad2_ Net-_X25-Pad4_ 3_and
X26  Net-_U34-Pad2_ Net-_U36-Pad2_ Net-_U35-Pad1_ Net-_X26-Pad4_ 3_and
X27  Net-_U34-Pad2_ Net-_U35-Pad2_ Net-_U36-Pad1_ Net-_X27-Pad4_ 3_and
X28  Net-_U34-Pad1_ Net-_U35-Pad1_ Net-_U36-Pad1_ Net-_X28-Pad4_ 3_and
X33  Net-_X25-Pad4_ Net-_X26-Pad4_ Net-_X27-Pad4_ Net-_X28-Pad4_ Net-_U37-Pad1_ 4_OR
U37  Net-_U37-Pad1_ Net-_U1-Pad11_ d_inverter
U17  Net-_U1-Pad2_ Net-_U13-Pad2_ d_inverter
U43  Net-_U14-Pad2_ Net-_U22-Pad1_ d_inverter
U16  Net-_U1-Pad1_ Net-_U14-Pad2_ d_inverter
U44  Net-_U13-Pad2_ Net-_U23-Pad1_ d_inverter
U18  Net-_U1-Pad3_ Net-_U13-Pad1_ d_inverter
U45  Net-_U13-Pad1_ Net-_U24-Pad1_ d_inverter
U28  Net-_U21-Pad2_ Net-_U20-Pad2_ Net-_U28-Pad3_ d_and
U29  Net-_U21-Pad2_ Net-_U19-Pad2_ Net-_U29-Pad3_ d_and
U30  Net-_U19-Pad2_ Net-_U20-Pad2_ Net-_U30-Pad3_ d_and
X1  Net-_U1-Pad6_ Net-_U1-Pad5_ ? Net-_U58-Pad1_ 3_and
U52  Net-_U46-Pad2_ Net-_U28-Pad3_ Net-_U52-Pad3_ d_nand
U53  Net-_U47-Pad2_ Net-_U29-Pad3_ Net-_U53-Pad3_ d_nand
U54  Net-_U48-Pad2_ Net-_U30-Pad3_ Net-_U54-Pad3_ d_nand
X3  Net-_U58-Pad2_ Net-_U52-Pad3_ Net-_U53-Pad3_ Net-_U54-Pad3_ Net-_U35-Pad1_ 4_and
U58  Net-_U58-Pad1_ Net-_U58-Pad2_ d_inverter
U20  Net-_U1-Pad5_ Net-_U20-Pad2_ d_inverter
U46  Net-_U19-Pad2_ Net-_U46-Pad2_ d_inverter
U19  Net-_U1-Pad4_ Net-_U19-Pad2_ d_inverter
U47  Net-_U20-Pad2_ Net-_U47-Pad2_ d_inverter
U21  Net-_U1-Pad6_ Net-_U21-Pad2_ d_inverter
U48  Net-_U21-Pad2_ Net-_U48-Pad2_ d_inverter
U32  Net-_U27-Pad2_ Net-_U26-Pad2_ Net-_U32-Pad3_ d_and
U33  Net-_U27-Pad2_ Net-_U25-Pad2_ Net-_U33-Pad3_ d_and
U42  Net-_U25-Pad2_ Net-_U26-Pad2_ Net-_U42-Pad3_ d_and
X2  Net-_U1-Pad9_ Net-_U1-Pad8_ ? Net-_U59-Pad1_ 3_and
U55  Net-_U49-Pad2_ Net-_U32-Pad3_ Net-_U55-Pad3_ d_nand
U56  Net-_U50-Pad2_ Net-_U33-Pad3_ Net-_U56-Pad3_ d_nand
U57  Net-_U51-Pad2_ Net-_U42-Pad3_ Net-_U57-Pad3_ d_nand
X4  Net-_U59-Pad2_ Net-_U55-Pad3_ Net-_U56-Pad3_ Net-_U57-Pad3_ Net-_U36-Pad1_ 4_and
U59  Net-_U59-Pad1_ Net-_U59-Pad2_ d_inverter
U26  Net-_U1-Pad8_ Net-_U26-Pad2_ d_inverter
U49  Net-_U25-Pad2_ Net-_U49-Pad2_ d_inverter
U25  Net-_U1-Pad7_ Net-_U25-Pad2_ d_inverter
U50  Net-_U26-Pad2_ Net-_U50-Pad2_ d_inverter
U27  Net-_U1-Pad9_ Net-_U27-Pad2_ d_inverter
U51  Net-_U27-Pad2_ Net-_U51-Pad2_ d_inverter
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ PORT

.end
