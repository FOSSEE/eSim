* C:\FOSSEE\eSim\library\SubcircuitLibrary\IC_LM397MFX\IC_LM397MFX.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 03/20/23 21:50:19

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
J1  Net-_J1-Pad1_ GND Net-_J1-Pad3_ jfet_n
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_J1-Pad1_ eSim_PNP
Q4  Net-_J1-Pad3_ Net-_Q1-Pad1_ Net-_J1-Pad1_ eSim_PNP
Q5  Net-_Q2-Pad3_ Net-_Q1-Pad1_ Net-_J1-Pad1_ eSim_PNP
Q8  Net-_D4-Pad1_ Net-_Q1-Pad1_ Net-_Q7-Pad3_ eSim_PNP
Q7  Net-_D2-Pad1_ Net-_Q1-Pad1_ Net-_Q7-Pad3_ eSim_PNP
Q10  Net-_Q10-Pad1_ Net-_Q1-Pad1_ Net-_J1-Pad1_ eSim_PNP
R2  Net-_Q1-Pad1_ Net-_Q1-Pad2_ 2k
R3  Net-_J1-Pad1_ Net-_Q7-Pad3_ 2.1k
Q2  Net-_Q1-Pad1_ Net-_J1-Pad3_ Net-_Q2-Pad3_ eSim_NPN
Q3  Net-_J1-Pad3_ Net-_Q2-Pad3_ GND eSim_NPN
D2  Net-_D2-Pad1_ Net-_D1-Pad2_ eSim_Diode
D1  Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
Q6  GND Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_PNP
Q9  Net-_D3-Pad1_ Net-_D1-Pad2_ Net-_Q10-Pad1_ eSim_PNP
Q12  Net-_Q11-Pad1_ Net-_D4-Pad2_ Net-_Q10-Pad1_ eSim_PNP
Q13  GND Net-_D5-Pad1_ Net-_D4-Pad2_ eSim_PNP
D4  Net-_D4-Pad1_ Net-_D4-Pad2_ eSim_Diode
D5  Net-_D5-Pad1_ Net-_D4-Pad2_ eSim_Diode
R1  Net-_Q2-Pad3_ GND 4.8k
Q11  Net-_Q11-Pad1_ Net-_D3-Pad1_ GND eSim_NPN
D3  Net-_D3-Pad1_ GND eSim_Diode
Q14  Net-_Q14-Pad1_ Net-_Q1-Pad1_ Net-_J1-Pad1_ eSim_PNP
Q15  Net-_Q14-Pad1_ Net-_Q11-Pad1_ GND eSim_NPN
Q16  Net-_Q16-Pad1_ Net-_Q14-Pad1_ GND eSim_NPN
U1  Net-_J1-Pad1_ Net-_D1-Pad1_ Net-_D5-Pad1_ Net-_Q16-Pad1_ PORT

.end
