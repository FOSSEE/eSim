* C:\FOSSEE\eSim\library\SubcircuitLibrary\MC1741_sub\MC1741_sub.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 07/09/24 14:51:22

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
D1  Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
Q1  Net-_D1-Pad2_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
Q7  Net-_D1-Pad2_ Net-_Q7-Pad2_ Net-_Q5-Pad3_ eSim_NPN
Q2  Net-_Q2-Pad1_ Net-_Q2-Pad2_ Net-_Q1-Pad3_ eSim_PNP
Q5  Net-_C1-Pad2_ Net-_Q2-Pad2_ Net-_Q5-Pad3_ eSim_PNP
Q8  Net-_Q2-Pad2_ Net-_D1-Pad2_ Net-_D1-Pad1_ eSim_PNP
Q4  Net-_D1-Pad1_ Net-_Q2-Pad1_ Net-_Q3-Pad2_ eSim_NPN
Q3  Net-_Q2-Pad1_ Net-_Q3-Pad2_ Net-_Q3-Pad3_ eSim_NPN
R2  Net-_Q3-Pad3_ Net-_D3-Pad2_ 1.0k
R3  Net-_Q3-Pad2_ Net-_D3-Pad2_ 50k
R4  Net-_Q6-Pad3_ Net-_D3-Pad2_ 1.0k
Q6  Net-_C1-Pad2_ Net-_Q3-Pad2_ Net-_Q6-Pad3_ eSim_NPN
Q9  Net-_Q2-Pad2_ Net-_D3-Pad1_ Net-_Q9-Pad3_ eSim_NPN
R5  Net-_Q9-Pad3_ Net-_D3-Pad2_ 5.0k
D2  Net-_D1-Pad1_ Net-_D2-Pad2_ eSim_Diode
R7  Net-_D2-Pad2_ Net-_D3-Pad1_ 39k
D3  Net-_D3-Pad1_ Net-_D3-Pad2_ eSim_Diode
Q12  Net-_C1-Pad1_ Net-_D2-Pad2_ Net-_D1-Pad1_ eSim_PNP
R9  Net-_C1-Pad1_ Net-_Q13-Pad2_ 4.5k
R10  Net-_D4-Pad2_ Net-_Q13-Pad2_ 7.5k
Q11  Net-_D4-Pad2_ Net-_C1-Pad2_ Net-_Q11-Pad3_ eSim_NPN
Q14  Net-_D4-Pad2_ Net-_Q11-Pad3_ Net-_Q10-Pad2_ eSim_NPN
Q10  Net-_C1-Pad2_ Net-_Q10-Pad2_ Net-_D3-Pad2_ eSim_NPN
R8  Net-_D3-Pad2_ Net-_Q11-Pad3_ 50k
R11  Net-_D3-Pad2_ Net-_Q10-Pad2_ 50
D4  Net-_D4-Pad1_ Net-_D4-Pad2_ eSim_Diode
D5  Net-_D5-Pad1_ Net-_D4-Pad1_ eSim_Diode
Q16  Net-_D1-Pad1_ Net-_C1-Pad1_ Net-_Q15-Pad2_ eSim_NPN
Q15  Net-_C1-Pad1_ Net-_Q15-Pad2_ Net-_D5-Pad1_ eSim_NPN
R12  Net-_D5-Pad1_ Net-_Q15-Pad2_ 25
R13  Net-_Q17-Pad3_ Net-_D5-Pad1_ 50
Q17  Net-_D3-Pad2_ Net-_D4-Pad2_ Net-_Q17-Pad3_ eSim_PNP
R1  Net-_Q7-Pad2_ Net-_R1-Pad2_ 3k
R6  Net-_D5-Pad1_ Net-_Q7-Pad2_ 6k
Q13  Net-_C1-Pad1_ Net-_Q13-Pad2_ Net-_D4-Pad2_ eSim_NPN
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 30p
U1  Net-_Q3-Pad3_ Net-_R1-Pad2_ Net-_Q1-Pad2_ Net-_D3-Pad2_ Net-_Q6-Pad3_ Net-_D5-Pad1_ Net-_D1-Pad1_ PORT

.end
