* C:\FOSSEE\eSim\library\SubcircuitLibrary\74HC688_sub\74HC688_sub.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 12/06/2024 12:19:51 PM

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U5  Net-_U2-Pad8_ Net-_U22-Pad1_ d_inverter
U6  Net-_U2-Pad9_ Net-_U22-Pad2_ d_inverter
U7  Net-_U2-Pad10_ Net-_U23-Pad1_ d_inverter
U8  Net-_U2-Pad11_ Net-_U23-Pad2_ d_inverter
U9  Net-_U2-Pad12_ Net-_U24-Pad1_ d_inverter
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ d_inverter
U11  Net-_U11-Pad1_ Net-_U11-Pad2_ d_inverter
U12  Net-_U12-Pad1_ Net-_U12-Pad2_ d_inverter
U13  Net-_U13-Pad1_ Net-_U13-Pad2_ d_inverter
U14  Net-_U14-Pad1_ Net-_U14-Pad2_ d_inverter
U15  Net-_U15-Pad1_ Net-_U15-Pad2_ d_inverter
U16  Net-_U16-Pad1_ Net-_U16-Pad2_ d_inverter
U17  Net-_U17-Pad1_ Net-_U17-Pad2_ d_inverter
U18  Net-_U18-Pad1_ Net-_U18-Pad2_ d_inverter
U19  Net-_U19-Pad1_ Net-_U19-Pad2_ d_inverter
U20  Net-_U20-Pad1_ Net-_U20-Pad2_ d_inverter
U21  Net-_U21-Pad1_ Net-_U21-Pad2_ d_inverter
U22  Net-_U22-Pad1_ Net-_U22-Pad2_ Net-_U22-Pad3_ d_xnor
U23  Net-_U23-Pad1_ Net-_U23-Pad2_ Net-_U23-Pad3_ d_xnor
U24  Net-_U24-Pad1_ Net-_U10-Pad2_ Net-_U24-Pad3_ d_xnor
U25  Net-_U11-Pad2_ Net-_U12-Pad2_ Net-_U25-Pad3_ d_xnor
U26  Net-_U13-Pad2_ Net-_U14-Pad2_ Net-_U26-Pad3_ d_xnor
U27  Net-_U15-Pad2_ Net-_U16-Pad2_ Net-_U27-Pad3_ d_xnor
U28  Net-_U17-Pad2_ Net-_U18-Pad2_ Net-_U28-Pad3_ d_xnor
U29  Net-_U19-Pad2_ Net-_U20-Pad2_ Net-_U29-Pad3_ d_xnor
U30  Net-_U22-Pad3_ Net-_U23-Pad3_ Net-_U30-Pad3_ d_and
U31  Net-_U24-Pad3_ Net-_U25-Pad3_ Net-_U31-Pad3_ d_and
U32  Net-_U26-Pad3_ Net-_U27-Pad3_ Net-_U32-Pad3_ d_and
U33  Net-_U28-Pad3_ Net-_U29-Pad3_ Net-_U33-Pad3_ d_and
U34  Net-_U30-Pad3_ Net-_U31-Pad3_ Net-_U34-Pad3_ d_and
U35  Net-_U32-Pad3_ Net-_U33-Pad3_ Net-_U35-Pad3_ d_and
U37  Net-_U36-Pad3_ Net-_U21-Pad2_ Net-_U37-Pad3_ d_nand
U36  Net-_U34-Pad3_ Net-_U35-Pad3_ Net-_U36-Pad3_ d_and
U38  Net-_U37-Pad3_ Net-_U1-Pad18_ dac_bridge_1
U2  Net-_U1-Pad16_ Net-_U1-Pad17_ Net-_U1-Pad14_ Net-_U1-Pad15_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad10_ Net-_U2-Pad8_ Net-_U2-Pad9_ Net-_U2-Pad10_ Net-_U2-Pad11_ Net-_U2-Pad12_ Net-_U10-Pad1_ Net-_U11-Pad1_ adc_bridge_7
U3  Net-_U1-Pad11_ Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U12-Pad1_ Net-_U13-Pad1_ Net-_U14-Pad1_ Net-_U15-Pad1_ Net-_U16-Pad1_ Net-_U17-Pad1_ Net-_U18-Pad1_ adc_bridge_7
U4  Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad1_ Net-_U19-Pad1_ Net-_U20-Pad1_ Net-_U21-Pad1_ adc_bridge_3
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ Net-_U1-Pad16_ Net-_U1-Pad17_ Net-_U1-Pad18_ PORT

.end
