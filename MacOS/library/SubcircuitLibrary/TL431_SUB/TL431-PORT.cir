* C:\FOSSEE2\eSim\library\SubcircuitLibrary\TL431-PORT\TL431-PORT.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 08/13/24 12:25:54

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
Q2  Net-_C2-Pad1_ Net-_Q2-Pad2_ Net-_Q2-Pad3_ eSim_NPN
Q4  Net-_C2-Pad2_ Net-_C2-Pad2_ Net-_Q2-Pad2_ eSim_NPN
R5  Net-_C2-Pad1_ Net-_Q7-Pad3_ 800
Q7  Net-_Q5-Pad1_ Net-_Q5-Pad1_ Net-_Q7-Pad3_ eSim_PNP
Q8  Net-_C2-Pad2_ Net-_Q5-Pad1_ Net-_Q8-Pad3_ eSim_PNP
R8  Net-_C2-Pad1_ Net-_Q8-Pad3_ 800
C2  Net-_C2-Pad1_ Net-_C2-Pad2_ 20p
Q10  Net-_C2-Pad1_ Net-_C2-Pad2_ Net-_Q10-Pad3_ eSim_NPN
R9  Net-_Q10-Pad3_ Net-_Q11-Pad2_ 150
R10  Net-_Q11-Pad2_ Net-_D1-Pad1_ 10k
Q11  Net-_C2-Pad1_ Net-_Q11-Pad2_ Net-_D1-Pad1_ eSim_NPN
D2  Net-_D1-Pad1_ Net-_C2-Pad1_ eSim_Diode
R2  Net-_Q2-Pad3_ Net-_R1-Pad1_ 3.28k
Q5  Net-_Q5-Pad1_ Net-_Q2-Pad3_ Net-_Q5-Pad3_ eSim_NPN
R6  Net-_Q5-Pad3_ Net-_C1-Pad1_ 4k
R1  Net-_R1-Pad1_ Net-_Q1-Pad1_ 2.4k
R3  Net-_R1-Pad1_ Net-_C1-Pad2_ 7.2k
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad1_ Net-_D1-Pad1_ eSim_NPN
Q3  Net-_C1-Pad2_ Net-_Q1-Pad1_ Net-_Q3-Pad3_ eSim_NPN
R4  Net-_Q3-Pad3_ Net-_D1-Pad1_ 800
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ capacitor_polarised
Q6  Net-_C1-Pad1_ Net-_C1-Pad2_ Net-_D1-Pad1_ eSim_NPN
Q9  Net-_C2-Pad2_ Net-_Q9-Pad2_ Net-_D1-Pad1_ eSim_NPN
R7  Net-_Q1-Pad1_ Net-_Q9-Pad2_ 1k
D1  Net-_D1-Pad1_ Net-_C2-Pad2_ eSim_Diode
U1  Net-_C2-Pad1_ Net-_Q2-Pad2_ Net-_D1-Pad1_ PORT

.end
