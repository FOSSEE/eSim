* C:\FOSSEE\eSim\library\SubcircuitLibrary\lm1458\lm1458.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 09/09/22 23:07:58

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
Q5  Net-_Q1-Pad1_ Net-_Q1-Pad1_ Net-_Q12-Pad3_ eSim_PNP
Q9  Net-_Q10-Pad1_ Net-_Q1-Pad1_ Net-_Q12-Pad3_ eSim_PNP
Q12  Net-_Q12-Pad1_ Net-_Q12-Pad1_ Net-_Q12-Pad3_ eSim_PNP
Q15  Net-_C1-Pad1_ Net-_Q12-Pad1_ Net-_Q12-Pad3_ eSim_PNP
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
Q2  Net-_Q2-Pad1_ Net-_Q10-Pad1_ Net-_Q1-Pad3_ eSim_PNP
Q8  Net-_Q1-Pad1_ Net-_Q8-Pad2_ Net-_Q6-Pad3_ eSim_NPN
Q6  Net-_C1-Pad2_ Net-_Q10-Pad1_ Net-_Q6-Pad3_ eSim_PNP
Q4  Net-_Q12-Pad3_ Net-_Q2-Pad1_ Net-_Q3-Pad2_ eSim_NPN
Q3  Net-_Q2-Pad1_ Net-_Q3-Pad2_ Net-_Q3-Pad3_ eSim_NPN
Q7  Net-_C1-Pad2_ Net-_Q3-Pad2_ Net-_Q7-Pad3_ eSim_NPN
R1  Net-_Q3-Pad3_ Net-_Q11-Pad3_ 1k
R2  Net-_Q3-Pad2_ Net-_Q11-Pad3_ 50k
R3  Net-_Q7-Pad3_ Net-_Q11-Pad3_ 1k
R5  Net-_Q12-Pad1_ Net-_R5-Pad2_ 19.5k
R6  Net-_R5-Pad2_ Net-_Q10-Pad2_ 19.5k
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
Q11  Net-_Q10-Pad2_ Net-_Q10-Pad2_ Net-_Q11-Pad3_ eSim_NPN
R4  Net-_Q10-Pad3_ Net-_Q11-Pad3_ 5k
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 30p
Q13  Net-_C1-Pad2_ Net-_Q13-Pad2_ Net-_Q11-Pad3_ eSim_NPN
Q14  Net-_D1-Pad2_ Net-_C1-Pad2_ Net-_Q14-Pad3_ eSim_NPN
R7  Net-_Q14-Pad3_ Net-_Q11-Pad3_ 50k
Q16  Net-_C1-Pad1_ Net-_Q16-Pad2_ Net-_D1-Pad2_ eSim_NPN
Q17  Net-_D1-Pad2_ Net-_Q14-Pad3_ Net-_Q13-Pad2_ eSim_NPN
R10  Net-_Q13-Pad2_ Net-_Q11-Pad3_ 50
R8  Net-_C1-Pad1_ Net-_Q16-Pad2_ 4.5k
R9  Net-_D1-Pad2_ Net-_Q16-Pad2_ 7.5k
Q18  Net-_C1-Pad1_ Net-_Q18-Pad2_ Net-_D2-Pad1_ eSim_NPN
Q19  Net-_Q12-Pad3_ Net-_C1-Pad1_ Net-_Q18-Pad2_ eSim_NPN
R11  Net-_Q18-Pad2_ Net-_D2-Pad1_ 25
D1  Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
D2  Net-_D2-Pad1_ Net-_D1-Pad1_ eSim_Diode
R12  Net-_D2-Pad1_ Net-_Q20-Pad3_ 50
Q20  Net-_Q11-Pad3_ Net-_D1-Pad2_ Net-_Q20-Pad3_ eSim_PNP
Q25  Net-_Q21-Pad1_ Net-_Q21-Pad1_ Net-_Q12-Pad3_ eSim_PNP
Q29  Net-_Q22-Pad2_ Net-_Q21-Pad1_ Net-_Q12-Pad3_ eSim_PNP
Q32  Net-_Q32-Pad1_ Net-_Q32-Pad1_ Net-_Q12-Pad3_ eSim_PNP
Q35  Net-_C2-Pad1_ Net-_Q32-Pad1_ Net-_Q12-Pad3_ eSim_PNP
Q21  Net-_Q21-Pad1_ Net-_Q21-Pad2_ Net-_Q21-Pad3_ eSim_NPN
Q22  Net-_Q22-Pad1_ Net-_Q22-Pad2_ Net-_Q21-Pad3_ eSim_PNP
Q28  Net-_Q21-Pad1_ Net-_Q28-Pad2_ Net-_Q26-Pad3_ eSim_NPN
Q26  Net-_C2-Pad2_ Net-_Q22-Pad2_ Net-_Q26-Pad3_ eSim_PNP
Q24  Net-_Q12-Pad3_ Net-_Q22-Pad1_ Net-_Q23-Pad2_ eSim_NPN
Q23  Net-_Q22-Pad1_ Net-_Q23-Pad2_ Net-_Q23-Pad3_ eSim_NPN
Q27  Net-_C2-Pad2_ Net-_Q23-Pad2_ Net-_Q27-Pad3_ eSim_NPN
R13  Net-_Q23-Pad3_ Net-_Q11-Pad3_ 1k
R14  Net-_Q23-Pad2_ Net-_Q11-Pad3_ 50k
R15  Net-_Q27-Pad3_ Net-_Q11-Pad3_ 1k
R17  Net-_Q32-Pad1_ Net-_R17-Pad2_ 19.5k
R18  Net-_R17-Pad2_ Net-_Q30-Pad2_ 19.5k
Q30  Net-_Q22-Pad2_ Net-_Q30-Pad2_ Net-_Q30-Pad3_ eSim_NPN
Q31  Net-_Q30-Pad2_ Net-_Q30-Pad2_ Net-_Q11-Pad3_ eSim_NPN
R16  Net-_Q30-Pad3_ Net-_Q11-Pad3_ 5k
C2  Net-_C2-Pad1_ Net-_C2-Pad2_ 30p
Q33  Net-_C2-Pad2_ Net-_Q33-Pad2_ Net-_Q11-Pad3_ eSim_NPN
Q34  Net-_D3-Pad2_ Net-_C2-Pad2_ Net-_Q34-Pad3_ eSim_NPN
R19  Net-_Q34-Pad3_ Net-_Q11-Pad3_ 50k
Q36  Net-_C2-Pad1_ Net-_Q36-Pad2_ Net-_D3-Pad2_ eSim_NPN
Q37  Net-_D3-Pad2_ Net-_Q34-Pad3_ Net-_Q33-Pad2_ eSim_NPN
R22  Net-_Q33-Pad2_ Net-_Q11-Pad3_ 50
R20  Net-_C2-Pad1_ Net-_Q36-Pad2_ 4.5k
R21  Net-_D3-Pad2_ Net-_Q36-Pad2_ 7.5k
Q38  Net-_C2-Pad1_ Net-_Q38-Pad2_ Net-_D4-Pad1_ eSim_NPN
Q39  Net-_Q12-Pad3_ Net-_C2-Pad1_ Net-_Q38-Pad2_ eSim_NPN
R23  Net-_Q38-Pad2_ Net-_D4-Pad1_ 25
D3  Net-_D3-Pad1_ Net-_D3-Pad2_ eSim_Diode
D4  Net-_D4-Pad1_ Net-_D3-Pad1_ eSim_Diode
R24  Net-_D4-Pad1_ Net-_Q40-Pad3_ 50
Q40  Net-_Q11-Pad3_ Net-_D3-Pad2_ Net-_Q40-Pad3_ eSim_PNP
U1  Net-_Q1-Pad2_ Net-_Q8-Pad2_ Net-_Q11-Pad3_ Net-_Q21-Pad2_ Net-_Q12-Pad3_ Net-_D2-Pad1_ Net-_Q28-Pad2_ Net-_D4-Pad1_ PORT

.end
