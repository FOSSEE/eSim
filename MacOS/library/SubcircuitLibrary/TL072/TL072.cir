* C:\FOSSEE\eSim\library\SubcircuitLibrary\TL072\TL072.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 3/14/2025 8:54:06 PM

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
J1  Net-_J1-Pad1_ ? Net-_J1-Pad3_ jfet_p
J2  Net-_J1-Pad1_ ? Net-_C1-Pad1_ jfet_p
Q3  Net-_J1-Pad1_ Net-_Q12-Pad2_ Net-_Q3-Pad3_ eSim_PNP
R3  Vcc Net-_Q3-Pad3_ 30R
Q1  Net-_J1-Pad3_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
Q4  Net-_C1-Pad1_ Net-_Q1-Pad2_ Net-_Q4-Pad3_ eSim_NPN
Q2  Vcc Net-_J1-Pad3_ Net-_Q1-Pad2_ eSim_NPN
Q5  Vcc Net-_C1-Pad1_ Net-_Q5-Pad3_ eSim_NPN
R1  Net-_Q1-Pad3_ Vee 1kR
R4  Net-_Q4-Pad3_ Vee 1kR
R2  Net-_Q1-Pad2_ Vee 50kR
R5  Net-_Q5-Pad3_ Vee 50kR
D1  Net-_C1-Pad1_ Net-_C1-Pad2_ eSim_Diode
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 18pF
Q7  Vcc Net-_Q12-Pad2_ Net-_Q10-Pad2_ eSim_PNP
Q12  Vcc Net-_Q12-Pad2_ Net-_Q12-Pad2_ eSim_PNP
Q6  Net-_Q10-Pad2_ Net-_Q10-Pad2_ Net-_Q6-Pad3_ eSim_NPN
Q10  Vcc Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
Q9  Net-_Q10-Pad2_ Net-_Q6-Pad3_ Net-_C1-Pad2_ eSim_NPN
R8  Net-_Q10-Pad3_ Net-_R10-Pad1_ 100R
R9  Net-_R10-Pad1_ Net-_Q11-Pad1_ 100R
Q11  Net-_Q11-Pad1_ Net-_C1-Pad2_ Vee eSim_PNP
Q8  Net-_C1-Pad2_ Net-_Q5-Pad3_ Net-_Q8-Pad3_ eSim_NPN
R7  Net-_Q8-Pad3_ Vee 100R
Q13  Net-_Q12-Pad2_ Net-_J3-Pad3_ Net-_Q13-Pad3_ eSim_NPN
R11  Net-_Q13-Pad3_ Vee 5kR
U1  Vee Net-_J3-Pad3_ zener
R10  Net-_R10-Pad1_ ? 200R
R6  Net-_Q6-Pad3_ Net-_C1-Pad2_ 100R
J3  Vcc Vcc Net-_J3-Pad3_ jfet_p
J4  Net-_J4-Pad1_ ? Net-_J4-Pad3_ jfet_p
J5  Net-_J4-Pad1_ ? Net-_C2-Pad1_ jfet_p
Q16  Net-_J4-Pad1_ Net-_Q16-Pad2_ Net-_Q16-Pad3_ eSim_PNP
R14  Vcc Net-_Q16-Pad3_ 30R
Q14  Net-_J4-Pad3_ Net-_Q14-Pad2_ Net-_Q14-Pad3_ eSim_NPN
Q17  Net-_C2-Pad1_ Net-_Q14-Pad2_ Net-_Q17-Pad3_ eSim_NPN
Q15  Vcc Net-_J4-Pad3_ Net-_Q14-Pad2_ eSim_NPN
Q18  Vcc Net-_C2-Pad1_ Net-_Q18-Pad3_ eSim_NPN
R12  Net-_Q14-Pad3_ Vee 1kR
R15  Net-_Q17-Pad3_ Vee 1kR
R13  Net-_Q14-Pad2_ Vee 50kR
R16  Net-_Q18-Pad3_ Vee 50kR
D2  Net-_C2-Pad1_ Net-_C2-Pad2_ eSim_Diode
C2  Net-_C2-Pad1_ Net-_C2-Pad2_ 18pF
Q20  Vcc Net-_Q16-Pad2_ Net-_Q19-Pad1_ eSim_PNP
Q25  Vcc Net-_Q16-Pad2_ Net-_Q16-Pad2_ eSim_PNP
Q19  Net-_Q19-Pad1_ Net-_Q19-Pad1_ Net-_Q19-Pad3_ eSim_NPN
Q23  Vcc Net-_Q19-Pad1_ Net-_Q23-Pad3_ eSim_NPN
Q22  Net-_Q19-Pad1_ Net-_Q19-Pad3_ Net-_C2-Pad2_ eSim_NPN
R19  Net-_Q23-Pad3_ Net-_R19-Pad2_ 100R
R20  Net-_R19-Pad2_ Net-_Q24-Pad1_ 100R
Q24  Net-_Q24-Pad1_ Net-_C2-Pad2_ Vee eSim_PNP
Q21  Net-_C2-Pad2_ Net-_Q18-Pad3_ Net-_Q21-Pad3_ eSim_NPN
R18  Net-_Q21-Pad3_ Vee 100R
Q26  Net-_Q16-Pad2_ Net-_J6-Pad3_ Net-_Q26-Pad3_ eSim_NPN
R22  Net-_Q26-Pad3_ Vee 5kR
U2  Vee Net-_J6-Pad3_ zener
R21  Net-_R19-Pad2_ ? 200R
R17  Net-_Q19-Pad3_ Net-_C2-Pad2_ 100R
J6  Vcc Vcc Net-_J6-Pad3_ jfet_p

.end
