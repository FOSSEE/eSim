* C:\FOSSEE\eSim\library\SubcircuitLibrary\743253\743253.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 5/4/2025 2:40:41 PM

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
M18  b11 Net-_M10-Pad1_ a1 a1 mosfet_p
M10  Net-_M10-Pad1_ c1 GND GND mosfet_n
M11  Net-_M10-Pad1_ c1 vdd vdd mosfet_p
M17  a1 c1 b11 b11 mosfet_n
M12  Net-_M12-Pad1_ sb0 Net-_M12-Pad3_ Net-_M12-Pad3_ mosfet_n
M13  Net-_M12-Pad3_ sb1 Net-_M13-Pad3_ Net-_M13-Pad3_ mosfet_n
M14  Net-_M13-Pad3_ e1 GND GND mosfet_n
M15  Net-_M12-Pad1_ sb1 vdd vdd mosfet_p
M16  Net-_M12-Pad1_ e1 vdd vdd mosfet_p
M9  Net-_M12-Pad1_ sb0 vdd vdd mosfet_p
M20  c1 Net-_M12-Pad1_ vdd vdd mosfet_p
M19  c1 Net-_M12-Pad1_ GND GND mosfet_n
M1  sb0 s0 GND GND mosfet_n
M5  sb0 s0 vdd vdd mosfet_p
M2  sb1 s1 GND GND mosfet_n
M6  sb1 s1 vdd vdd mosfet_p
M3  e1 oe1 GND GND mosfet_n
M7  e1 oe1 vdd vdd mosfet_p
M30  b12 Net-_M22-Pad1_ a1 a1 mosfet_p
M22  Net-_M22-Pad1_ c2 GND GND mosfet_n
M23  Net-_M22-Pad1_ c2 vdd vdd mosfet_p
M29  a1 c2 b12 b12 mosfet_n
M24  Net-_M21-Pad1_ s0 Net-_M24-Pad3_ Net-_M24-Pad3_ mosfet_n
M25  Net-_M24-Pad3_ sb1 Net-_M25-Pad3_ Net-_M25-Pad3_ mosfet_n
M26  Net-_M25-Pad3_ e1 GND GND mosfet_n
M27  Net-_M21-Pad1_ sb1 vdd vdd mosfet_p
M28  Net-_M21-Pad1_ e1 vdd vdd mosfet_p
M21  Net-_M21-Pad1_ s0 vdd vdd mosfet_p
M32  c2 Net-_M21-Pad1_ vdd vdd mosfet_p
M31  c2 Net-_M21-Pad1_ GND GND mosfet_n
M42  b13 Net-_M34-Pad1_ a1 a1 mosfet_p
M34  Net-_M34-Pad1_ c3 GND GND mosfet_n
M35  Net-_M34-Pad1_ c3 vdd vdd mosfet_p
M41  a1 c3 b13 b13 mosfet_n
M36  Net-_M33-Pad1_ sb0 Net-_M36-Pad3_ Net-_M36-Pad3_ mosfet_n
M37  Net-_M36-Pad3_ s1 Net-_M37-Pad3_ Net-_M37-Pad3_ mosfet_n
M38  Net-_M37-Pad3_ e1 GND GND mosfet_n
M39  Net-_M33-Pad1_ s1 vdd vdd mosfet_p
M40  Net-_M33-Pad1_ e1 vdd vdd mosfet_p
M33  Net-_M33-Pad1_ sb0 vdd vdd mosfet_p
M44  c3 Net-_M33-Pad1_ vdd vdd mosfet_p
M43  c3 Net-_M33-Pad1_ GND GND mosfet_n
M54  b14 Net-_M46-Pad1_ a1 a1 mosfet_p
M46  Net-_M46-Pad1_ c4 GND GND mosfet_n
M47  Net-_M46-Pad1_ c4 vdd vdd mosfet_p
M53  a1 c4 b14 b14 mosfet_n
M48  Net-_M45-Pad1_ s0 Net-_M48-Pad3_ Net-_M48-Pad3_ mosfet_n
M49  Net-_M48-Pad3_ s1 Net-_M49-Pad3_ Net-_M49-Pad3_ mosfet_n
M50  Net-_M49-Pad3_ e1 GND GND mosfet_n
M51  Net-_M45-Pad1_ s1 vdd vdd mosfet_p
M52  Net-_M45-Pad1_ e1 vdd vdd mosfet_p
M45  Net-_M45-Pad1_ s0 vdd vdd mosfet_p
M56  c4 Net-_M45-Pad1_ vdd vdd mosfet_p
M55  c4 Net-_M45-Pad1_ GND GND mosfet_n
M4  e2 oe2 GND GND mosfet_n
M8  e2 oe2 vdd vdd mosfet_p
M66  b21 Net-_M58-Pad1_ a1 a1 mosfet_p
M58  Net-_M58-Pad1_ c5 GND GND mosfet_n
M59  Net-_M58-Pad1_ c5 vdd vdd mosfet_p
M65  a1 c5 b21 b21 mosfet_n
M60  Net-_M57-Pad1_ sb0 Net-_M60-Pad3_ Net-_M60-Pad3_ mosfet_n
M61  Net-_M60-Pad3_ sb1 Net-_M61-Pad3_ Net-_M61-Pad3_ mosfet_n
M62  Net-_M61-Pad3_ e2 GND GND mosfet_n
M63  Net-_M57-Pad1_ sb1 vdd vdd mosfet_p
M64  Net-_M57-Pad1_ e2 vdd vdd mosfet_p
M57  Net-_M57-Pad1_ sb0 vdd vdd mosfet_p
M68  c5 Net-_M57-Pad1_ vdd vdd mosfet_p
M67  c5 Net-_M57-Pad1_ GND GND mosfet_n
M78  b22 Net-_M70-Pad1_ a1 a1 mosfet_p
M70  Net-_M70-Pad1_ c6 GND GND mosfet_n
M71  Net-_M70-Pad1_ c6 vdd vdd mosfet_p
M77  a1 c6 b22 b22 mosfet_n
M72  Net-_M69-Pad1_ s0 Net-_M72-Pad3_ Net-_M72-Pad3_ mosfet_n
M73  Net-_M72-Pad3_ sb1 Net-_M73-Pad3_ Net-_M73-Pad3_ mosfet_n
M74  Net-_M73-Pad3_ e2 GND GND mosfet_n
M75  Net-_M69-Pad1_ sb1 vdd vdd mosfet_p
M76  Net-_M69-Pad1_ e2 vdd vdd mosfet_p
M69  Net-_M69-Pad1_ s0 vdd vdd mosfet_p
M80  c6 Net-_M69-Pad1_ vdd vdd mosfet_p
M79  c6 Net-_M69-Pad1_ GND GND mosfet_n
M90  b23 Net-_M82-Pad1_ a1 a1 mosfet_p
M82  Net-_M82-Pad1_ c7 GND GND mosfet_n
M83  Net-_M82-Pad1_ c7 vdd vdd mosfet_p
M89  a1 c7 b23 b23 mosfet_n
M84  Net-_M81-Pad1_ sb0 Net-_M84-Pad3_ Net-_M84-Pad3_ mosfet_n
M85  Net-_M84-Pad3_ s1 Net-_M85-Pad3_ Net-_M85-Pad3_ mosfet_n
M86  Net-_M85-Pad3_ e2 GND GND mosfet_n
M87  Net-_M81-Pad1_ s1 vdd vdd mosfet_p
M88  Net-_M81-Pad1_ e2 vdd vdd mosfet_p
M81  Net-_M81-Pad1_ sb0 vdd vdd mosfet_p
M92  c7 Net-_M81-Pad1_ vdd vdd mosfet_p
M91  c7 Net-_M81-Pad1_ GND GND mosfet_n
M102  b24 Net-_M102-Pad2_ a1 a1 mosfet_p
M94  Net-_M102-Pad2_ c8 GND GND mosfet_n
M95  Net-_M102-Pad2_ c8 vdd vdd mosfet_p
M101  a1 c8 b24 b24 mosfet_n
M96  Net-_M100-Pad1_ s0 Net-_M96-Pad3_ Net-_M96-Pad3_ mosfet_n
M97  Net-_M96-Pad3_ s1 Net-_M97-Pad3_ Net-_M97-Pad3_ mosfet_n
M98  Net-_M97-Pad3_ e2 GND GND mosfet_n
M99  Net-_M100-Pad1_ s1 vdd vdd mosfet_p
M100  Net-_M100-Pad1_ e2 vdd vdd mosfet_p
M93  Net-_M100-Pad1_ s0 vdd vdd mosfet_p
M104  c8 Net-_M100-Pad1_ vdd vdd mosfet_p
M103  c8 Net-_M100-Pad1_ GND GND mosfet_n

.end
