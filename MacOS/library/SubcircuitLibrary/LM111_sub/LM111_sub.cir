* C:\FOSSEE\eSim\library\SubcircuitLibrary\LM111_sub\LM111_sub.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 04/06/2024 10:55:30 AM

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
Q2  Net-_J1-Pad2_ Net-_Q2-Pad2_ Net-_Q2-Pad3_ eSim_PNP
Q1  Net-_J1-Pad2_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_PNP
U2  Net-_U2-PadIN_ Net-_Q1-Pad3_ zener
U3  Net-_U2-PadIN_ Net-_Q2-Pad3_ zener
Q6  Net-_Q11-Pad2_ Net-_Q2-Pad3_ Net-_Q5-Pad3_ eSim_NPN
Q8  Net-_Q5-Pad3_ Net-_Q12-Pad2_ Net-_Q8-Pad3_ eSim_NPN
R7  Net-_J1-Pad2_ Net-_Q8-Pad3_ 250
Q4  Net-_Q1-Pad3_ Net-_Q3-Pad2_ Net-_Q4-Pad3_ eSim_PNP
Q3  Net-_Q2-Pad3_ Net-_Q3-Pad2_ Net-_Q3-Pad3_ eSim_PNP
R2  Net-_Q3-Pad3_ Net-_J1-Pad1_ 1.3k
R4  Net-_Q4-Pad3_ Net-_J1-Pad1_ 1.3k
R3  Net-_Q4-Pad3_ Net-_R3-Pad2_ 300
R1  Net-_Q3-Pad3_ Net-_Q9-Pad3_ 300
Q7  Net-_J1-Pad1_ Net-_J1-Pad1_ Net-_Q7-Pad3_ eSim_NPN
R6  Net-_Q3-Pad2_ Net-_Q7-Pad3_ 70
R5  Net-_Q10-Pad2_ Net-_Q3-Pad2_ 1.2k
Q5  Net-_Q10-Pad2_ Net-_Q1-Pad3_ Net-_Q5-Pad3_ eSim_NPN
Q9  Net-_Q11-Pad1_ Net-_Q3-Pad2_ Net-_Q9-Pad3_ eSim_NPN
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
Q11  Net-_Q11-Pad1_ Net-_Q11-Pad2_ Net-_Q10-Pad3_ eSim_NPN
Q12  Net-_Q10-Pad3_ Net-_Q12-Pad2_ Net-_Q12-Pad3_ eSim_NPN
R10  Net-_J1-Pad2_ Net-_Q12-Pad3_ 200
R11  Net-_Q12-Pad2_ Net-_R11-Pad2_ 60
Q14  Net-_Q12-Pad2_ Net-_Q14-Pad2_ Net-_J1-Pad2_ eSim_NPN
R14  Net-_Q14-Pad2_ Net-_R11-Pad2_ 450
R15  Net-_J1-Pad2_ Net-_Q14-Pad2_ 2k
Q17  Net-_J1-Pad3_ Net-_Q16-Pad3_ Net-_Q17-Pad3_ eSim_NPN
R13  Net-_R11-Pad2_ Net-_Q16-Pad3_ 400
Q16  Net-_Q13-Pad3_ Net-_J1-Pad3_ Net-_Q16-Pad3_ eSim_NPN
R8  Net-_Q11-Pad2_ Net-_Q3-Pad2_ 1.2k
Q18  Net-_J1-Pad2_ Net-_J1-Pad2_ Net-_Q17-Pad3_ eSim_PNP
Q15  Net-_Q11-Pad1_ Net-_Q13-Pad3_ Net-_Q15-Pad3_ eSim_PNP
Q13  Net-_J1-Pad1_ Net-_Q10-Pad1_ Net-_Q13-Pad3_ eSim_NPN
R9  Net-_Q10-Pad1_ Net-_J1-Pad1_ 750
R12  Net-_Q11-Pad1_ Net-_J1-Pad1_ 600
J1  Net-_J1-Pad1_ Net-_J1-Pad2_ Net-_J1-Pad3_ jfet_n
R16  Net-_Q22-Pad3_ Net-_Q15-Pad3_ 4k
Q20  Net-_Q15-Pad3_ Net-_Q15-Pad3_ Net-_Q20-Pad3_ eSim_NPN
Q21  Net-_J1-Pad2_ Net-_Q21-Pad2_ Net-_Q20-Pad3_ eSim_PNP
Q22  Net-_J1-Pad1_ Net-_Q15-Pad3_ Net-_Q22-Pad3_ eSim_NPN
R17  Net-_Q23-Pad2_ Net-_Q22-Pad3_ 130
R18  Net-_Q19-Pad2_ Net-_Q23-Pad2_ 600
R19  Net-_Q19-Pad3_ Net-_Q19-Pad2_ 4
Q19  Net-_Q15-Pad3_ Net-_Q19-Pad2_ Net-_Q19-Pad3_ eSim_NPN
Q23  Net-_Q21-Pad2_ Net-_Q23-Pad2_ Net-_Q19-Pad2_ eSim_NPN
U1  Net-_Q19-Pad3_ Net-_Q1-Pad2_ Net-_Q2-Pad2_ Net-_J1-Pad2_ Net-_R3-Pad2_ Net-_Q9-Pad3_ Net-_Q21-Pad2_ Net-_J1-Pad1_ PORT

.end
