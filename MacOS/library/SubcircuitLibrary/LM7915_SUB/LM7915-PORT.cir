* C:\FOSSEE2\eSim\library\SubcircuitLibrary\LM7915-PORT\LM7915-PORT.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 05/28/24 11:21:26

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
J1  Net-_J1-Pad1_ Net-_J1-Pad1_ Net-_J1-Pad3_ jfet_n
U2  Net-_J1-Pad3_ Net-_Q14-Pad1_ zener
U3  Net-_Q1-Pad3_ Net-_Q14-Pad1_ zener
Q1  Net-_J1-Pad1_ Net-_J1-Pad3_ Net-_Q1-Pad3_ eSim_PNP
Q3  Net-_Q3-Pad1_ Net-_Q3-Pad1_ Net-_Q3-Pad3_ eSim_NPN
R2  Net-_Q14-Pad1_ Net-_Q3-Pad1_ 1.4k
R3  Net-_Q3-Pad3_ Net-_Q9-Pad2_ 7k
R4  Net-_Q9-Pad2_ Net-_Q4-Pad3_ 15k
Q4  Net-_Q2-Pad2_ Net-_Q1-Pad3_ Net-_Q4-Pad3_ eSim_PNP
Q2  Net-_Q1-Pad3_ Net-_Q2-Pad2_ Net-_Q2-Pad3_ eSim_NPN
Q5  Net-_Q2-Pad2_ Net-_Q2-Pad2_ Net-_Q5-Pad3_ eSim_NPN
R1  Net-_Q2-Pad3_ Net-_J1-Pad1_ 750
R5  Net-_Q5-Pad3_ Net-_J1-Pad1_ 1k
Q6  Net-_Q10-Pad2_ Net-_Q2-Pad2_ Net-_Q6-Pad3_ eSim_NPN
R6  Net-_Q6-Pad3_ Net-_J1-Pad1_ 6k
R7  Net-_Q7-Pad1_ Net-_J1-Pad1_ 20k
Q8  Net-_C1-Pad1_ Net-_Q7-Pad1_ Net-_Q10-Pad1_ eSim_NPN
Q7  Net-_Q7-Pad1_ Net-_Q3-Pad1_ Net-_Q14-Pad1_ eSim_PNP
Q9  Net-_Q14-Pad1_ Net-_Q9-Pad2_ Net-_Q10-Pad3_ eSim_NPN
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_PNP
Q11  Net-_Q10-Pad1_ Net-_Q11-Pad2_ Net-_J1-Pad1_ eSim_NPN
R8  Net-_Q11-Pad2_ Net-_Q10-Pad1_ 20k
R9  Net-_Q10-Pad1_ Net-_C1-Pad2_ 20k
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 20p
Q13  Net-_C1-Pad1_ Net-_C1-Pad2_ Net-_J1-Pad1_ eSim_NPN
Q14  Net-_Q14-Pad1_ Net-_Q14-Pad2_ Net-_Q12-Pad3_ eSim_NPN
Q12  Net-_C1-Pad1_ Net-_Q10-Pad2_ Net-_Q12-Pad3_ eSim_PNP
Q16  Net-_Q15-Pad3_ Net-_C2-Pad2_ Net-_J1-Pad1_ eSim_NPN
Q15  Net-_C1-Pad1_ Net-_Q15-Pad2_ Net-_Q15-Pad3_ eSim_NPN
R10  Net-_Q15-Pad2_ Net-_Q15-Pad3_ 3k
C2  Net-_C1-Pad1_ Net-_C2-Pad2_ 10p
R11  Net-_C2-Pad2_ Net-_Q18-Pad1_ 5k
R12  Net-_Q14-Pad1_ Net-_Q17-Pad1_ 4k
Q17  Net-_Q17-Pad1_ Net-_C1-Pad1_ Net-_Q15-Pad2_ eSim_NPN
R13  Net-_Q15-Pad2_ Net-_R13-Pad2_ 10k
R14  Net-_R13-Pad2_ Net-_Q18-Pad1_ 600
Q18  Net-_Q18-Pad1_ Net-_Q18-Pad2_ Net-_Q18-Pad3_ eSim_NPN
R15  Net-_R13-Pad2_ Net-_Q18-Pad2_ 15k
Q19  Net-_Q19-Pad1_ Net-_Q15-Pad2_ Net-_Q19-Pad3_ eSim_NPN
Q20  Net-_Q19-Pad1_ Net-_Q19-Pad3_ Net-_Q20-Pad3_ eSim_NPN
R16  Net-_Q19-Pad3_ Net-_Q20-Pad3_ 2k
R18  Net-_Q14-Pad2_ Net-_Q19-Pad1_ 30k
R17  Net-_Q14-Pad1_ Net-_Q14-Pad2_ 5k
R20  Net-_R20-Pad1_ Net-_Q18-Pad3_ 20k
R19  Net-_Q18-Pad3_ Net-_Q20-Pad3_ 150
U4  Net-_R20-Pad1_ Net-_Q19-Pad1_ zener
R21  Net-_Q20-Pad3_ Net-_J1-Pad1_ 0.2
U1  Net-_Q14-Pad1_ Net-_J1-Pad1_ Net-_Q19-Pad1_ PORT

.end
