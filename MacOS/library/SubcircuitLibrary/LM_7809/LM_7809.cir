* C:\FOSSEE\eSim\library\SubcircuitLibrary\LM_7809\LM_7809.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 05/14/22 00:48:35

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
Q3  Net-_Q3-Pad1_ Net-_Q3-Pad2_ Net-_Q14-Pad3_ eSim_NPN
Q6  Net-_C1-Pad2_ Net-_Q3-Pad2_ Net-_Q6-Pad3_ eSim_NPN
Q4  Net-_Q2-Pad3_ Net-_Q3-Pad1_ Net-_Q3-Pad2_ eSim_NPN
Q14  Net-_C1-Pad1_ Net-_Q11-Pad3_ Net-_Q14-Pad3_ eSim_NPN
Q11  Net-_C1-Pad1_ Net-_C1-Pad2_ Net-_Q11-Pad3_ eSim_NPN
Q5  Net-_Q5-Pad1_ Net-_Q10-Pad3_ Net-_Q2-Pad3_ eSim_NPN
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
Q8  Net-_Q12-Pad2_ Net-_Q10-Pad1_ Net-_Q5-Pad1_ eSim_NPN
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
Q2  Net-_Q12-Pad2_ Net-_Q2-Pad2_ Net-_Q2-Pad3_ eSim_NPN
Q9  Net-_Q12-Pad1_ Net-_Q9-Pad2_ Net-_Q14-Pad3_ eSim_NPN
Q16  Net-_Q16-Pad1_ Net-_Q12-Pad1_ Net-_Q16-Pad3_ eSim_NPN
Q17  Net-_Q16-Pad1_ Net-_Q16-Pad3_ Net-_Q17-Pad3_ eSim_NPN
Q13  Net-_Q12-Pad1_ Net-_Q13-Pad2_ Net-_Q10-Pad1_ eSim_NPN
Q7  Net-_Q12-Pad2_ Net-_Q12-Pad2_ Net-_Q7-Pad3_ eSim_PNP
Q12  Net-_Q12-Pad1_ Net-_Q12-Pad2_ Net-_Q12-Pad3_ eSim_PNP
Q15  Net-_Q14-Pad3_ Net-_C1-Pad1_ Net-_Q12-Pad1_ eSim_PNP
R6  Net-_Q2-Pad3_ Net-_Q3-Pad1_ 1K
R10  Net-_Q10-Pad3_ Net-_Q2-Pad3_ 6K
R11  Net-_Q2-Pad3_ Net-_C1-Pad2_ 20K
R7  Net-_Q3-Pad2_ Net-_Q14-Pad3_ 6K
R9  Net-_Q6-Pad3_ Net-_Q14-Pad3_ 1K
R12  Net-_Q11-Pad3_ Net-_Q14-Pad3_ 6K
R18  Net-_Q17-Pad3_ Net-_Q10-Pad1_ 0.3
R19  Net-_Q10-Pad1_ Net-_Q10-Pad2_ 385
R20  Net-_Q10-Pad2_ Net-_Q14-Pad3_ 293
R16  Net-_Q16-Pad3_ Net-_Q10-Pad1_ 200
R17  Net-_Q17-Pad3_ Net-_Q13-Pad2_ 240
R1  Net-_Q16-Pad1_ Net-_Q1-Pad2_ 100K
R8  Net-_Q16-Pad1_ Net-_Q7-Pad3_ 100
R13  Net-_Q16-Pad1_ Net-_Q12-Pad3_ 50
R2  Net-_Q16-Pad1_ Net-_Q1-Pad1_ 500
R15  Net-_Q16-Pad1_ Net-_R15-Pad2_ 10K
R3  Net-_Q1-Pad3_ Net-_Q2-Pad2_ 3.3K
R4  Net-_Q2-Pad2_ Net-_Q9-Pad2_ 2.7K
R5  Net-_Q9-Pad2_ Net-_Q14-Pad3_ 500
R14  Net-_Q12-Pad1_ Net-_C1-Pad1_ 6K
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 30pF
U3  Net-_Q12-Pad1_ Net-_R15-Pad2_ zener
U2  Net-_Q14-Pad3_ Net-_Q1-Pad2_ zener
U1  Net-_Q16-Pad1_ Net-_Q10-Pad1_ Net-_Q14-Pad3_ PORT

.end
