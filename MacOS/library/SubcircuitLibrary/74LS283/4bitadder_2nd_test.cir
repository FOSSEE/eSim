* C:\Users\senba\Desktop\FOSSEE\eSim\library\SubcircuitLibrary\4bitadder_2nd_test\4bitadder_2nd_test.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 03/14/25 19:59:00

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U2  /Cin Net-_U2-Pad2_ d_inverter
U4  /b1 /a1 Net-_U10-Pad1_ d_nor
U8  /b1 /a1 Net-_U7-Pad1_ d_nand
U12  /b2 /a2 Net-_U12-Pad3_ d_nor
U15  /b2 /a2 Net-_U14-Pad1_ d_nand
U18  /b3 /a3 Net-_U18-Pad3_ d_nor
U21  /b3 /a3 Net-_U21-Pad3_ d_nand
U25  /b4 /a4 Net-_U25-Pad3_ d_nor
U26  /b4 /a4 Net-_U26-Pad3_ d_nand
U1  /Cin /a1 /s1 /b1 /s2 /a2 /b2 /a3 /b3 /s3 /a4 /b4 /s4 /cout PORT
U3  Net-_U2-Pad2_ Net-_U3-Pad2_ d_inverter
U6  Net-_U10-Pad1_ Net-_U6-Pad2_ d_inverter
U7  Net-_U7-Pad1_ Net-_U6-Pad2_ Net-_U5-Pad1_ d_and
U5  Net-_U5-Pad1_ Net-_U3-Pad2_ /s1 d_xor
U9  Net-_U7-Pad1_ Net-_U2-Pad2_ Net-_U10-Pad2_ d_and
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ Net-_U10-Pad3_ d_nor
U13  Net-_U12-Pad3_ Net-_U13-Pad2_ d_inverter
U14  Net-_U14-Pad1_ Net-_U13-Pad2_ Net-_U11-Pad1_ d_and
U11  Net-_U11-Pad1_ Net-_U10-Pad3_ /s2 d_xor
X1  Net-_U14-Pad1_ Net-_U7-Pad1_ Net-_U2-Pad2_ Net-_U16-Pad2_ 3_and
U17  Net-_U10-Pad1_ Net-_U14-Pad1_ Net-_U16-Pad1_ d_and
U16  Net-_U16-Pad1_ Net-_U16-Pad2_ Net-_U16-Pad3_ d_or
U20  Net-_U12-Pad3_ Net-_U16-Pad3_ Net-_U19-Pad1_ d_or
U19  Net-_U19-Pad1_ Net-_U19-Pad2_ d_inverter
U23  Net-_U18-Pad3_ Net-_U23-Pad2_ d_inverter
U24  Net-_U21-Pad3_ Net-_U23-Pad2_ Net-_U22-Pad1_ d_and
U22  Net-_U22-Pad1_ Net-_U19-Pad2_ /s3 d_xor
X2  Net-_U21-Pad3_ Net-_U14-Pad1_ Net-_U7-Pad1_ Net-_U2-Pad2_ Net-_X2-Pad5_ 4_and
X3  Net-_U10-Pad1_ Net-_U21-Pad3_ Net-_U14-Pad1_ Net-_X3-Pad4_ 3_and
U28  Net-_U12-Pad3_ Net-_U21-Pad3_ Net-_U28-Pad3_ d_and
X4  Net-_U18-Pad3_ Net-_U28-Pad3_ Net-_X3-Pad4_ Net-_X2-Pad5_ Net-_U27-Pad1_ 4_OR
U27  Net-_U27-Pad1_ Net-_U27-Pad2_ d_inverter
U29  Net-_U29-Pad1_ Net-_U27-Pad2_ /s4 d_xor
U30  Net-_U25-Pad3_ Net-_U30-Pad2_ d_inverter
U31  Net-_U26-Pad3_ Net-_U30-Pad2_ Net-_U29-Pad1_ d_and
X5  Net-_U14-Pad1_ Net-_U7-Pad1_ Net-_U2-Pad2_ Net-_X5-Pad4_ 3_and
X6  Net-_U26-Pad3_ Net-_U21-Pad3_ Net-_X5-Pad4_ Net-_X6-Pad4_ 3_and
X7  Net-_U10-Pad1_ Net-_U26-Pad3_ Net-_U21-Pad3_ Net-_U14-Pad1_ Net-_X7-Pad5_ 4_and
X8  Net-_U12-Pad3_ Net-_U26-Pad3_ Net-_U21-Pad3_ Net-_X8-Pad4_ 3_and
U32  Net-_U18-Pad3_ Net-_U26-Pad3_ Net-_U32-Pad3_ d_and
X9  Net-_U32-Pad3_ Net-_X8-Pad4_ Net-_X7-Pad5_ Net-_X6-Pad4_ Net-_U33-Pad2_ 4_OR
U33  Net-_U25-Pad3_ Net-_U33-Pad2_ Net-_U33-Pad3_ d_or
U34  Net-_U33-Pad3_ /cout d_inverter

.end
