* C:\FOSSEE\eSim\library\SubcircuitLibrary\LM380_sub\LM380_sub.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 17/06/2024 11:51:25 PM

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_PNP
Q2  Net-_Q2-Pad1_ Net-_Q1-Pad3_ Net-_Q2-Pad3_ eSim_PNP
Q5  Net-_C1-Pad1_ Net-_Q5-Pad2_ Net-_Q5-Pad3_ eSim_PNP
Q4  Net-_Q4-Pad1_ Net-_Q4-Pad1_ Net-_Q11-Pad1_ eSim_PNP
Q7  Net-_Q1-Pad1_ Net-_Q7-Pad2_ Net-_Q5-Pad2_ eSim_PNP
Q3  Net-_Q2-Pad1_ Net-_Q2-Pad1_ Net-_Q1-Pad1_ eSim_NPN
Q6  Net-_C1-Pad1_ Net-_Q2-Pad1_ Net-_Q1-Pad1_ eSim_NPN
Q11  Net-_Q11-Pad1_ Net-_D1-Pad1_ Net-_Q11-Pad3_ eSim_NPN
Q12  Net-_Q10-Pad3_ Net-_Q10-Pad1_ Net-_Q1-Pad1_ eSim_NPN
Q9  Net-_C1-Pad2_ Net-_C1-Pad1_ Net-_Q1-Pad1_ eSim_NPN
Q8  Net-_D1-Pad1_ Net-_Q4-Pad1_ Net-_Q11-Pad1_ eSim_PNP
Q10  Net-_Q10-Pad1_ Net-_C1-Pad2_ Net-_Q10-Pad3_ eSim_PNP
R1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ 150k
R4  Net-_Q2-Pad3_ Net-_Q5-Pad3_ 125K
R3  Net-_Q2-Pad3_ Net-_R2-Pad1_ 17.5K
R2  Net-_R2-Pad1_ Net-_Q4-Pad1_ 17.5k
R5  Net-_Q5-Pad3_ Net-_R5-Pad2_ 22.5K
R6  Net-_Q1-Pad1_ Net-_Q7-Pad2_ 150K
R7  Net-_R5-Pad2_ Net-_Q11-Pad3_ 0.5
R8  Net-_Q10-Pad3_ Net-_R5-Pad2_ 0.5
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 10pF
D1  Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
D2  Net-_D1-Pad2_ Net-_C1-Pad2_ eSim_Diode
U1  Net-_R2-Pad1_ Net-_Q7-Pad2_ Net-_Q1-Pad1_ Net-_Q1-Pad1_ Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad1_ Net-_R5-Pad2_ Net-_Q11-Pad1_ Net-_Q1-Pad1_ Net-_Q1-Pad1_ Net-_Q1-Pad1_ Net-_Q11-Pad1_ Net-_Q11-Pad1_ PORT

.end
