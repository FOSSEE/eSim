* C:\FOSSEE\eSim\library\SubcircuitLibrary\LM124_SUBcircuit\LM124_SUBcircuit.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 09/09/24 22:06:28

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
Q4  Net-_Q4-Pad1_ Net-_Q2-Pad3_ Net-_I2-Pad2_ eSim_PNP
Q10  Net-_C2-Pad2_ Net-_Q10-Pad2_ Net-_I2-Pad2_ eSim_PNP
Q12  Net-_I10-Pad2_ Net-_Q12-Pad2_ Net-_Q10-Pad2_ eSim_PNP
Q2  Net-_I10-Pad2_ Net-_Q2-Pad2_ Net-_Q2-Pad3_ eSim_PNP
Q6  Net-_Q4-Pad1_ Net-_Q4-Pad1_ Net-_I10-Pad2_ eSim_NPN
Q8  Net-_C2-Pad2_ Net-_Q4-Pad1_ Net-_I10-Pad2_ eSim_NPN
R2  Net-_R2-Pad1_ Net-_Q2-Pad2_ 2k
I2  Net-_I1-Pad1_ Net-_I2-Pad2_ 6uA
I4  Net-_I1-Pad1_ Net-_I4-Pad2_ 4uA
I8  Net-_I1-Pad1_ Net-_C2-Pad1_ 100uA
C2  Net-_C2-Pad1_ Net-_C2-Pad2_ 20pF
Q14  Net-_I10-Pad2_ Net-_C2-Pad2_ Net-_I4-Pad2_ eSim_PNP
Q16  Net-_I1-Pad1_ Net-_I4-Pad2_ Net-_I6-Pad1_ eSim_NPN
I6  Net-_I6-Pad1_ Net-_I10-Pad2_ 50uA
Q18  Net-_C2-Pad1_ Net-_I6-Pad1_ Net-_I10-Pad2_ eSim_NPN
Q22  Net-_I1-Pad1_ Net-_C2-Pad1_ Net-_Q22-Pad3_ eSim_NPN
Q20  Net-_C2-Pad1_ Net-_Q20-Pad2_ Net-_I10-Pad1_ eSim_NPN
Q25  Net-_I1-Pad1_ Net-_Q22-Pad3_ Net-_Q20-Pad2_ eSim_NPN
I10  Net-_I10-Pad1_ Net-_I10-Pad2_ 50uA
R6  Net-_Q20-Pad2_ Net-_I10-Pad1_ 500
Q26  Net-_I10-Pad2_ Net-_C2-Pad1_ Net-_I10-Pad1_ eSim_PNP
R4  Net-_Q2-Pad2_ Net-_I10-Pad1_ 10k
Q29  Net-_Q29-Pad1_ Net-_Q27-Pad3_ Net-_I11-Pad2_ eSim_PNP
Q34  Net-_C3-Pad2_ Net-_Q34-Pad2_ Net-_I11-Pad2_ eSim_PNP
Q37  Net-_I10-Pad2_ Net-_Q37-Pad2_ Net-_Q34-Pad2_ eSim_PNP
Q27  Net-_I10-Pad2_ Net-_Q27-Pad2_ Net-_Q27-Pad3_ eSim_PNP
Q30  Net-_Q29-Pad1_ Net-_Q29-Pad1_ Net-_I10-Pad2_ eSim_NPN
Q33  Net-_C3-Pad2_ Net-_Q29-Pad1_ Net-_I10-Pad2_ eSim_NPN
R7  Net-_R7-Pad1_ Net-_Q27-Pad2_ 2k
I11  Net-_I1-Pad1_ Net-_I11-Pad2_ 6uA
I13  Net-_I1-Pad1_ Net-_I13-Pad2_ 4uA
I17  Net-_I1-Pad1_ Net-_C3-Pad1_ 100uA
C3  Net-_C3-Pad1_ Net-_C3-Pad2_ 20pF
Q39  Net-_I10-Pad2_ Net-_C3-Pad2_ Net-_I13-Pad2_ eSim_PNP
Q41  Net-_I1-Pad1_ Net-_I13-Pad2_ Net-_I15-Pad1_ eSim_NPN
I15  Net-_I15-Pad1_ Net-_I10-Pad2_ 50uA
Q43  Net-_C3-Pad1_ Net-_I15-Pad1_ Net-_I10-Pad2_ eSim_NPN
Q47  Net-_I1-Pad1_ Net-_C3-Pad1_ Net-_Q47-Pad3_ eSim_NPN
Q45  Net-_C3-Pad1_ Net-_Q45-Pad2_ Net-_I18-Pad1_ eSim_NPN
Q49  Net-_I1-Pad1_ Net-_Q47-Pad3_ Net-_Q45-Pad2_ eSim_NPN
I18  Net-_I18-Pad1_ Net-_I10-Pad2_ 50uA
R11  Net-_Q45-Pad2_ Net-_I18-Pad1_ 500
Q50  Net-_I10-Pad2_ Net-_C3-Pad1_ Net-_I18-Pad1_ eSim_PNP
R9  Net-_Q27-Pad2_ Net-_I18-Pad1_ 10k
Q3  Net-_Q3-Pad1_ Net-_Q1-Pad3_ Net-_I1-Pad2_ eSim_PNP
Q9  Net-_C1-Pad2_ Net-_Q11-Pad3_ Net-_I1-Pad2_ eSim_PNP
Q11  Net-_I10-Pad2_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_PNP
Q1  Net-_I10-Pad2_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_PNP
Q5  Net-_Q3-Pad1_ Net-_Q3-Pad1_ Net-_I10-Pad2_ eSim_NPN
Q7  Net-_C1-Pad2_ Net-_Q3-Pad1_ Net-_I10-Pad2_ eSim_NPN
R1  Net-_R1-Pad1_ Net-_Q1-Pad2_ 2k
I1  Net-_I1-Pad1_ Net-_I1-Pad2_ 6uA
I3  Net-_I1-Pad1_ Net-_I3-Pad2_ 4uA
I7  Net-_I1-Pad1_ Net-_C1-Pad1_ 100uA
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 20pF
Q13  Net-_I10-Pad2_ Net-_C1-Pad2_ Net-_I3-Pad2_ eSim_PNP
Q15  Net-_I1-Pad1_ Net-_I3-Pad2_ Net-_I5-Pad1_ eSim_NPN
I5  Net-_I5-Pad1_ Net-_I10-Pad2_ 50uA
Q17  Net-_C1-Pad1_ Net-_I5-Pad1_ Net-_I10-Pad2_ eSim_NPN
Q21  Net-_I1-Pad1_ Net-_C1-Pad1_ Net-_Q21-Pad3_ eSim_NPN
Q19  Net-_C1-Pad1_ Net-_Q19-Pad2_ Net-_I9-Pad1_ eSim_NPN
Q23  Net-_I1-Pad1_ Net-_Q21-Pad3_ Net-_Q19-Pad2_ eSim_NPN
I9  Net-_I9-Pad1_ Net-_I10-Pad2_ 50uA
R5  Net-_Q19-Pad2_ Net-_I9-Pad1_ 500
Q24  Net-_I10-Pad2_ Net-_C1-Pad1_ Net-_I9-Pad1_ eSim_PNP
R3  Net-_Q1-Pad2_ Net-_I9-Pad1_ 10k
Q31  Net-_Q31-Pad1_ Net-_Q28-Pad3_ Net-_I12-Pad2_ eSim_PNP
Q36  Net-_C4-Pad2_ Net-_Q36-Pad2_ Net-_I12-Pad2_ eSim_PNP
Q38  Net-_I10-Pad2_ Net-_Q38-Pad2_ Net-_Q36-Pad2_ eSim_PNP
Q28  Net-_I10-Pad2_ Net-_Q28-Pad2_ Net-_Q28-Pad3_ eSim_PNP
Q32  Net-_Q31-Pad1_ Net-_Q31-Pad1_ Net-_I10-Pad2_ eSim_NPN
Q35  Net-_C4-Pad2_ Net-_Q31-Pad1_ Net-_I10-Pad2_ eSim_NPN
R8  Net-_R8-Pad1_ Net-_Q28-Pad2_ 2k
I12  Net-_I1-Pad1_ Net-_I12-Pad2_ 6uA
I14  Net-_I1-Pad1_ Net-_I14-Pad2_ 4uA
I19  Net-_I1-Pad1_ Net-_C4-Pad1_ 100uA
C4  Net-_C4-Pad1_ Net-_C4-Pad2_ 20pF
Q40  Net-_I10-Pad2_ Net-_C4-Pad2_ Net-_I14-Pad2_ eSim_PNP
Q42  Net-_I1-Pad1_ Net-_I14-Pad2_ Net-_I16-Pad1_ eSim_NPN
I16  Net-_I16-Pad1_ Net-_I10-Pad2_ 50uA
Q44  Net-_C4-Pad1_ Net-_I16-Pad1_ Net-_I10-Pad2_ eSim_NPN
Q48  Net-_I1-Pad1_ Net-_C4-Pad1_ Net-_Q48-Pad3_ eSim_NPN
Q46  Net-_C4-Pad1_ Net-_Q46-Pad2_ Net-_I20-Pad1_ eSim_NPN
Q51  Net-_I1-Pad1_ Net-_Q48-Pad3_ Net-_Q46-Pad2_ eSim_NPN
I20  Net-_I20-Pad1_ Net-_I10-Pad2_ 50uA
R12  Net-_Q46-Pad2_ Net-_I20-Pad1_ 500
Q52  Net-_I10-Pad2_ Net-_C4-Pad1_ Net-_I20-Pad1_ eSim_PNP
R10  Net-_Q28-Pad2_ Net-_I20-Pad1_ 10k
U1  Net-_I10-Pad1_ Net-_R2-Pad1_ Net-_Q12-Pad2_ Net-_I1-Pad1_ Net-_Q37-Pad2_ Net-_R7-Pad1_ Net-_I18-Pad1_ Net-_I9-Pad1_ Net-_R1-Pad1_ Net-_Q11-Pad2_ Net-_I10-Pad2_ Net-_Q38-Pad2_ Net-_R8-Pad1_ Net-_I20-Pad1_ PORT

.end
