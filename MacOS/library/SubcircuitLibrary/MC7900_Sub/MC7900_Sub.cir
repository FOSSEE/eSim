* C:\FOSSEE\eSim\library\SubcircuitLibrary\MC7900_Sub\MC7900_Sub.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/28/24 16:30:41

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
D1  Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
D2  Net-_D1-Pad2_ Net-_D2-Pad2_ eSim_Diode
D3  Net-_D2-Pad2_ Net-_D3-Pad2_ eSim_Diode
Q1  Net-_Q1-Pad1_ Net-_D3-Pad2_ Net-_Q1-Pad3_ eSim_PNP
Q3  Net-_Q1-Pad1_ Net-_D4-Pad2_ Net-_Q1-Pad3_ eSim_PNP
R1  Net-_D1-Pad1_ Net-_Q1-Pad3_ 3.6k
J1  Net-_D3-Pad2_ Net-_J1-Pad2_ Net-_J1-Pad2_ jfet_n
Q4  Net-_D4-Pad2_ Net-_Q1-Pad1_ Net-_Q2-Pad2_ eSim_NPN
Q2  Net-_Q1-Pad1_ Net-_Q2-Pad2_ Net-_J1-Pad2_ eSim_NPN
Q6  Net-_Q2-Pad2_ Net-_Q2-Pad2_ Net-_J1-Pad2_ eSim_NPN
Q7  Net-_Q7-Pad1_ Net-_Q5-Pad3_ Net-_D4-Pad2_ eSim_NPN
Q5  Net-_D1-Pad1_ Net-_Q5-Pad2_ Net-_Q5-Pad3_ eSim_NPN
R3  Net-_D1-Pad1_ Net-_Q5-Pad2_ 2.4k
R2  Net-_Q5-Pad3_ Net-_D4-Pad2_ 1.2k
Q9  Net-_D1-Pad1_ Net-_Q7-Pad1_ Net-_Q10-Pad2_ eSim_NPN
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
R4  Net-_Q5-Pad2_ Net-_Q7-Pad1_ 25
R6  Net-_Q10-Pad2_ Net-_D4-Pad2_ 12k
Q11  Net-_D1-Pad1_ Net-_Q10-Pad1_ Net-_Q11-Pad3_ eSim_NPN
Q12  Net-_D4-Pad2_ Net-_Q12-Pad2_ Net-_D1-Pad1_ eSim_PNP
Q13  Net-_Q12-Pad2_ Net-_Q11-Pad3_ Net-_D4-Pad2_ eSim_NPN
R8  Net-_Q10-Pad3_ Net-_D4-Pad2_ 1.0k
Q14  Net-_Q14-Pad1_ Net-_Q14-Pad2_ Net-_D1-Pad1_ eSim_PNP
R12  Net-_D1-Pad1_ Net-_Q14-Pad2_ 2.0k
R14  Net-_Q14-Pad2_ Net-_Q17-Pad2_ 1.0k
R13  Net-_D1-Pad1_ Net-_Q14-Pad2_ 8.0k
R15  Net-_Q17-Pad2_ Net-_D4-Pad2_ 1.6k
Q17  Net-_Q14-Pad2_ Net-_Q17-Pad2_ Net-_D4-Pad2_ eSim_NPN
R16  Net-_Q16-Pad1_ Net-_Q16-Pad2_ 20k
R7  Net-_D1-Pad1_ Net-_Q10-Pad1_ 14.7k
R9  Net-_Q11-Pad3_ Net-_D4-Pad1_ 4.0k
D4  Net-_D4-Pad1_ Net-_D4-Pad2_ eSim_Diode
R10  Net-_D1-Pad1_ Net-_Q12-Pad2_ 2.0k
Q19  Net-_D1-Pad1_ Net-_D4-Pad2_ Net-_Q18-Pad3_ eSim_NPN
Q22  Net-_D1-Pad1_ Net-_Q22-Pad2_ Net-_Q21-Pad3_ eSim_NPN
R21  Net-_D1-Pad1_ Net-_Q26-Pad1_ 4.5k
R11  Net-_Q14-Pad1_ Net-_J1-Pad2_ 2.0k
Q18  Net-_Q16-Pad1_ Net-_Q18-Pad2_ Net-_Q18-Pad3_ eSim_PNP
Q20  Net-_Q18-Pad2_ Net-_Q18-Pad2_ Net-_Q18-Pad3_ eSim_PNP
Q21  Net-_Q18-Pad2_ Net-_Q18-Pad2_ Net-_Q21-Pad3_ eSim_PNP
Q23  Net-_C1-Pad2_ Net-_Q18-Pad2_ Net-_Q21-Pad3_ eSim_PNP
Q8  Net-_Q18-Pad2_ Net-_Q2-Pad2_ Net-_Q8-Pad3_ eSim_NPN
R5  Net-_Q8-Pad3_ Net-_J1-Pad2_ 1.1k
Q15  Net-_C1-Pad2_ Net-_Q14-Pad1_ Net-_J1-Pad2_ eSim_NPN
Q16  Net-_Q16-Pad1_ Net-_Q16-Pad2_ Net-_J1-Pad2_ eSim_NPN
R17  Net-_C1-Pad1_ Net-_Q16-Pad1_ 20k
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 20pF
C2  Net-_C1-Pad2_ Net-_C2-Pad2_ 10pF
Q24  Net-_C1-Pad2_ Net-_C1-Pad1_ Net-_J1-Pad2_ eSim_NPN
Q25  Net-_C1-Pad2_ Net-_C2-Pad2_ Net-_J1-Pad2_ eSim_NPN
R18  Net-_Q27-Pad1_ Net-_R18-Pad2_ 10k
U1  Net-_C2-Pad2_ Net-_R18-Pad2_ zener
Q26  Net-_Q26-Pad1_ Net-_C1-Pad2_ Net-_Q26-Pad3_ eSim_NPN
R22  Net-_Q26-Pad3_ Net-_Q28-Pad3_ 10k
R19  Net-_Q28-Pad3_ Net-_C2-Pad2_ 240
R20  Net-_Q27-Pad3_ Net-_C2-Pad2_ 750
Q27  Net-_Q27-Pad1_ Net-_Q26-Pad3_ Net-_Q27-Pad3_ eSim_NPN
Q28  Net-_Q27-Pad1_ Net-_Q27-Pad3_ Net-_Q28-Pad3_ eSim_NPN
R25  Net-_Q28-Pad3_ Net-_J1-Pad2_ 0.3
R24  Net-_Q22-Pad2_ Net-_Q27-Pad1_ 1k
R23  Net-_D1-Pad1_ Net-_Q22-Pad2_ 185
U2  Net-_J1-Pad2_ Net-_Q27-Pad1_ Net-_D1-Pad1_ PORT

.end
