* C:\FOSSEE\eSim\library\SubcircuitLibrary\OP470\OP470.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 02/01/25 19:52:16

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
R1  ? Net-_C1-Pad2_ 10k
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 10n
R5  Net-_C1-Pad1_ Net-_Q19-Pad2_ 10k
C3  Net-_C3-Pad1_ Net-_C1-Pad2_ 10n
R3  Net-_C3-Pad1_ Net-_Q19-Pad2_ 10k
Q1  Net-_C1-Pad2_ Net-_D1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
D1  Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
D5  Net-_D5-Pad1_ Net-_D1-Pad1_ eSim_Diode
D2  Net-_D1-Pad2_ Net-_D2-Pad2_ eSim_Diode
D6  Net-_D2-Pad2_ Net-_D5-Pad1_ eSim_Diode
Q3  Net-_Q19-Pad2_ Net-_D5-Pad1_ Net-_Q1-Pad3_ eSim_NPN
I1  Net-_C11-Pad2_ Net-_D2-Pad2_ dc
Q6  Net-_Q10-Pad2_ Net-_Q10-Pad2_ Net-_C1-Pad1_ eSim_PNP
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_C1-Pad1_ eSim_PNP
Q5  Net-_D1-Pad2_ Net-_Q10-Pad1_ Net-_Q10-Pad2_ eSim_PNP
Q9  Net-_D5-Pad1_ Net-_Q10-Pad1_ Net-_Q10-Pad2_ eSim_PNP
I5  Net-_I5-Pad1_ ? dc
I7  Net-_I7-Pad1_ Net-_C1-Pad1_ dc
R7  ? Net-_C7-Pad1_ 10k
R9  Net-_I7-Pad1_ Net-_C5-Pad1_ 10k
Q17  Net-_C7-Pad1_ Net-_C1-Pad2_ Net-_I8-Pad2_ eSim_NPN
Q19  Net-_C5-Pad1_ Net-_Q19-Pad2_ Net-_I8-Pad2_ eSim_NPN
Q12  Net-_Q10-Pad1_ Net-_D2-Pad2_ Net-_Q12-Pad3_ eSim_NPN
Q15  Net-_I8-Pad2_ Net-_Q12-Pad3_ Net-_I3-Pad2_ eSim_NPN
I3  Net-_C11-Pad2_ Net-_I3-Pad2_ dc
I8  Net-_C11-Pad2_ Net-_I8-Pad2_ dc
Q21  Net-_Q21-Pad1_ Net-_Q21-Pad2_ Net-_I5-Pad1_ eSim_PNP
Q27  Net-_C11-Pad1_ Net-_Q21-Pad2_ Net-_I7-Pad1_ eSim_PNP
C5  Net-_C5-Pad1_ Net-_C5-Pad2_ 10n
C7  Net-_C7-Pad1_ Net-_C7-Pad2_ 10n
Q23  Net-_Q21-Pad1_ Net-_Q21-Pad1_ Net-_C7-Pad2_ eSim_NPN
Q28  Net-_C11-Pad1_ Net-_Q21-Pad1_ Net-_C5-Pad2_ eSim_NPN
Q24  Net-_C7-Pad2_ Net-_C7-Pad2_ Net-_C11-Pad2_ eSim_NPN
Q29  Net-_C5-Pad2_ Net-_C7-Pad2_ Net-_C11-Pad2_ eSim_NPN
R11  Net-_Q19-Pad2_ Net-_C9-Pad2_ 10k
C9  Net-_C11-Pad1_ Net-_C9-Pad2_ 10n
Q33  Net-_C1-Pad1_ ? Net-_I11-Pad2_ eSim_NPN
Q35  Net-_C11-Pad2_ ? Net-_I13-Pad1_ eSim_PNP
I13  Net-_I13-Pad1_ Net-_C1-Pad1_ dc
C11  Net-_C11-Pad1_ Net-_C11-Pad2_ 10n
I11  Net-_C11-Pad2_ Net-_I11-Pad2_ dc
Q37  Net-_C1-Pad1_ Net-_I13-Pad1_ Net-_Q37-Pad3_ eSim_NPN
Q39  Net-_C11-Pad2_ Net-_I11-Pad2_ Net-_Q37-Pad3_ eSim_PNP
R13  ? Net-_C13-Pad2_ 10k
C13  Net-_C1-Pad1_ Net-_C13-Pad2_ 10n
R16  Net-_C1-Pad1_ Net-_Q43-Pad1_ 10k
C14  Net-_C14-Pad1_ Net-_C13-Pad2_ 10n
R15  Net-_C14-Pad1_ Net-_Q43-Pad1_ 10k
Q41  Net-_C13-Pad2_ Net-_D10-Pad1_ Net-_Q41-Pad3_ eSim_NPN
D9  Net-_D11-Pad2_ Net-_D10-Pad1_ eSim_Diode
D11  Net-_D11-Pad1_ Net-_D11-Pad2_ eSim_Diode
D10  Net-_D10-Pad1_ Net-_D10-Pad2_ eSim_Diode
D12  Net-_D10-Pad2_ Net-_D11-Pad1_ eSim_Diode
Q43  Net-_Q43-Pad1_ Net-_D11-Pad1_ Net-_Q41-Pad3_ eSim_NPN
I15  Net-_C11-Pad2_ Net-_D10-Pad2_ dc
Q46  Net-_Q44-Pad3_ Net-_Q44-Pad3_ Net-_C1-Pad1_ eSim_PNP
Q50  Net-_Q44-Pad2_ Net-_Q44-Pad3_ Net-_C1-Pad1_ eSim_PNP
Q44  Net-_D10-Pad1_ Net-_Q44-Pad2_ Net-_Q44-Pad3_ eSim_PNP
Q48  Net-_D11-Pad1_ Net-_Q44-Pad2_ Net-_Q44-Pad3_ eSim_PNP
I18  Net-_I18-Pad1_ ? dc
I21  Net-_I21-Pad1_ Net-_C1-Pad1_ dc
R19  ? Net-_C18-Pad1_ 10k
R21  Net-_I21-Pad1_ Net-_C17-Pad1_ 10k
Q56  Net-_C18-Pad1_ Net-_C13-Pad2_ Net-_I22-Pad2_ eSim_NPN
Q59  Net-_C17-Pad1_ Net-_Q43-Pad1_ Net-_I22-Pad2_ eSim_NPN
Q51  Net-_Q44-Pad2_ Net-_D10-Pad2_ Net-_Q51-Pad3_ eSim_NPN
Q55  Net-_I22-Pad2_ Net-_Q51-Pad3_ Net-_I17-Pad2_ eSim_NPN
I17  Net-_C11-Pad2_ Net-_I17-Pad2_ dc
I22  Net-_C11-Pad2_ Net-_I22-Pad2_ dc
Q61  Net-_Q61-Pad1_ Net-_Q61-Pad2_ Net-_I18-Pad1_ eSim_PNP
Q67  Net-_C21-Pad1_ Net-_Q61-Pad2_ Net-_I21-Pad1_ eSim_PNP
C17  Net-_C17-Pad1_ Net-_C17-Pad2_ 10n
C18  Net-_C18-Pad1_ Net-_C18-Pad2_ 10n
Q62  Net-_Q61-Pad1_ Net-_Q61-Pad1_ Net-_C18-Pad2_ eSim_NPN
Q68  Net-_C21-Pad1_ Net-_Q61-Pad1_ Net-_C17-Pad2_ eSim_NPN
Q63  Net-_C18-Pad2_ Net-_C18-Pad2_ Net-_C11-Pad2_ eSim_NPN
Q69  Net-_C17-Pad2_ Net-_C18-Pad2_ Net-_C11-Pad2_ eSim_NPN
R23  Net-_Q43-Pad1_ Net-_C21-Pad2_ 10k
C21  Net-_C21-Pad1_ Net-_C21-Pad2_ 10n
Q73  Net-_C1-Pad1_ ? Net-_I25-Pad2_ eSim_NPN
Q75  Net-_C11-Pad2_ ? Net-_I26-Pad1_ eSim_PNP
I26  Net-_I26-Pad1_ Net-_C1-Pad1_ dc
C23  Net-_C21-Pad1_ Net-_C11-Pad2_ 10n
I25  Net-_C11-Pad2_ Net-_I25-Pad2_ dc
Q77  Net-_C1-Pad1_ Net-_I26-Pad1_ Net-_Q77-Pad3_ eSim_NPN
Q78  Net-_C11-Pad2_ Net-_I25-Pad2_ Net-_Q77-Pad3_ eSim_PNP
R2  ? Net-_C2-Pad2_ 10k
C2  Net-_C1-Pad1_ Net-_C2-Pad2_ 10n
R6  Net-_C1-Pad1_ Net-_Q20-Pad2_ 10k
C4  Net-_C4-Pad1_ Net-_C2-Pad2_ 10n
R4  Net-_C4-Pad1_ Net-_Q20-Pad2_ 10k
Q2  Net-_C2-Pad2_ Net-_D3-Pad2_ Net-_Q2-Pad3_ eSim_NPN
D3  Net-_D3-Pad1_ Net-_D3-Pad2_ eSim_Diode
D7  Net-_D7-Pad1_ Net-_D3-Pad1_ eSim_Diode
D4  Net-_D3-Pad2_ Net-_D4-Pad2_ eSim_Diode
D8  Net-_D4-Pad2_ Net-_D7-Pad1_ eSim_Diode
Q4  Net-_Q20-Pad2_ Net-_D7-Pad1_ Net-_Q2-Pad3_ eSim_NPN
I2  Net-_C11-Pad2_ Net-_D4-Pad2_ dc
Q8  Net-_Q11-Pad3_ Net-_Q11-Pad3_ Net-_C1-Pad1_ eSim_PNP
Q13  Net-_Q11-Pad2_ Net-_Q11-Pad3_ Net-_C1-Pad1_ eSim_PNP
Q7  Net-_D3-Pad2_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_PNP
Q11  Net-_D7-Pad1_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_PNP
I6  Net-_I6-Pad1_ ? dc
I9  Net-_I9-Pad1_ Net-_C1-Pad1_ dc
R8  ? Net-_C8-Pad1_ 10k
R10  Net-_I9-Pad1_ Net-_C6-Pad1_ 10k
Q18  Net-_C8-Pad1_ Net-_C2-Pad2_ Net-_I10-Pad2_ eSim_NPN
Q20  Net-_C6-Pad1_ Net-_Q20-Pad2_ Net-_I10-Pad2_ eSim_NPN
Q14  Net-_Q11-Pad2_ Net-_D4-Pad2_ Net-_Q14-Pad3_ eSim_NPN
Q16  Net-_I10-Pad2_ Net-_Q14-Pad3_ Net-_I4-Pad2_ eSim_NPN
I4  Net-_C11-Pad2_ Net-_I4-Pad2_ dc
I10  Net-_C11-Pad2_ Net-_I10-Pad2_ dc
Q22  Net-_Q22-Pad1_ Net-_Q22-Pad2_ Net-_I6-Pad1_ eSim_PNP
Q30  Net-_C10-Pad1_ Net-_Q22-Pad2_ Net-_I9-Pad1_ eSim_PNP
C6  Net-_C6-Pad1_ Net-_C6-Pad2_ 10n
C8  Net-_C8-Pad1_ Net-_C8-Pad2_ 10n
Q25  Net-_Q22-Pad1_ Net-_Q22-Pad1_ Net-_C8-Pad2_ eSim_NPN
Q31  Net-_C10-Pad1_ Net-_Q22-Pad1_ Net-_C6-Pad2_ eSim_NPN
Q26  Net-_C8-Pad2_ Net-_C8-Pad2_ Net-_C11-Pad2_ eSim_NPN
Q32  Net-_C6-Pad2_ Net-_C8-Pad2_ Net-_C11-Pad2_ eSim_NPN
R12  Net-_Q20-Pad2_ Net-_C10-Pad2_ 10k
C10  Net-_C10-Pad1_ Net-_C10-Pad2_ 10n
Q34  Net-_C1-Pad1_ ? Net-_I12-Pad2_ eSim_NPN
Q36  Net-_C11-Pad2_ ? Net-_I14-Pad1_ eSim_PNP
I14  Net-_I14-Pad1_ Net-_C1-Pad1_ dc
C12  Net-_C10-Pad1_ Net-_C11-Pad2_ 10n
I12  Net-_C11-Pad2_ Net-_I12-Pad2_ dc
Q38  Net-_C1-Pad1_ Net-_I14-Pad1_ Net-_Q38-Pad3_ eSim_NPN
Q40  Net-_C11-Pad2_ Net-_I12-Pad2_ Net-_Q38-Pad3_ eSim_PNP
R14  ? Net-_C15-Pad2_ 10k
C15  Net-_C1-Pad1_ Net-_C15-Pad2_ 10n
R18  Net-_C1-Pad1_ Net-_Q45-Pad1_ 10k
C16  Net-_C16-Pad1_ Net-_C15-Pad2_ 10n
R17  Net-_C16-Pad1_ Net-_Q45-Pad1_ 10k
Q42  Net-_C15-Pad2_ Net-_D13-Pad2_ Net-_Q42-Pad3_ eSim_NPN
D13  Net-_D13-Pad1_ Net-_D13-Pad2_ eSim_Diode
D15  Net-_D15-Pad1_ Net-_D13-Pad1_ eSim_Diode
D14  Net-_D13-Pad2_ Net-_D14-Pad2_ eSim_Diode
D16  Net-_D14-Pad2_ Net-_D15-Pad1_ eSim_Diode
Q45  Net-_Q45-Pad1_ Net-_D15-Pad1_ Net-_Q42-Pad3_ eSim_NPN
I16  Net-_C11-Pad2_ Net-_D14-Pad2_ dc
Q49  Net-_Q47-Pad3_ Net-_Q47-Pad3_ Net-_C1-Pad1_ eSim_PNP
Q53  Net-_Q47-Pad2_ Net-_Q47-Pad3_ Net-_C1-Pad1_ eSim_PNP
Q47  Net-_D13-Pad2_ Net-_Q47-Pad2_ Net-_Q47-Pad3_ eSim_PNP
Q52  Net-_D15-Pad1_ Net-_Q47-Pad2_ Net-_Q47-Pad3_ eSim_PNP
I20  Net-_I20-Pad1_ ? dc
I23  Net-_I23-Pad1_ Net-_C1-Pad1_ dc
R20  ? Net-_C20-Pad1_ 10k
R22  Net-_I23-Pad1_ Net-_C19-Pad1_ 10k
Q58  Net-_C20-Pad1_ Net-_C15-Pad2_ Net-_I24-Pad2_ eSim_NPN
Q60  Net-_C19-Pad1_ Net-_Q45-Pad1_ Net-_I24-Pad2_ eSim_NPN
Q54  Net-_Q47-Pad2_ Net-_D14-Pad2_ Net-_Q54-Pad3_ eSim_NPN
Q57  Net-_I24-Pad2_ Net-_Q54-Pad3_ Net-_I19-Pad2_ eSim_NPN
I19  Net-_C11-Pad2_ Net-_I19-Pad2_ dc
I24  Net-_C11-Pad2_ Net-_I24-Pad2_ dc
Q64  Net-_Q64-Pad1_ Net-_Q64-Pad2_ Net-_I20-Pad1_ eSim_PNP
Q70  Net-_C22-Pad1_ Net-_Q64-Pad2_ Net-_I23-Pad1_ eSim_PNP
C19  Net-_C19-Pad1_ Net-_C19-Pad2_ 10n
C20  Net-_C20-Pad1_ Net-_C20-Pad2_ 10n
Q65  Net-_Q64-Pad1_ Net-_Q64-Pad1_ Net-_C20-Pad2_ eSim_NPN
Q71  Net-_C22-Pad1_ Net-_Q64-Pad1_ Net-_C19-Pad2_ eSim_NPN
Q66  Net-_C20-Pad2_ Net-_C20-Pad2_ Net-_C11-Pad2_ eSim_NPN
Q72  Net-_C19-Pad2_ Net-_C20-Pad2_ Net-_C11-Pad2_ eSim_NPN
R24  Net-_Q45-Pad1_ Net-_C22-Pad2_ 10k
C22  Net-_C22-Pad1_ Net-_C22-Pad2_ 10n
Q74  Net-_C1-Pad1_ ? Net-_I27-Pad2_ eSim_NPN
Q76  Net-_C11-Pad2_ ? Net-_I28-Pad1_ eSim_PNP
I28  Net-_I28-Pad1_ Net-_C1-Pad1_ dc
C24  Net-_C22-Pad1_ Net-_C11-Pad2_ 10n
I27  Net-_C11-Pad2_ Net-_I27-Pad2_ dc
Q79  Net-_C1-Pad1_ Net-_I28-Pad1_ Net-_Q79-Pad3_ eSim_NPN
Q80  Net-_C11-Pad2_ Net-_I27-Pad2_ Net-_Q79-Pad3_ eSim_PNP
U1  Net-_Q37-Pad3_ Net-_D1-Pad2_ Net-_D5-Pad1_ Net-_C1-Pad1_ Net-_D7-Pad1_ Net-_D3-Pad2_ Net-_Q38-Pad3_ Net-_Q79-Pad3_ Net-_D13-Pad2_ Net-_D15-Pad1_ Net-_C11-Pad2_ Net-_D11-Pad1_ Net-_D10-Pad1_ Net-_Q77-Pad3_ PORT

.end
