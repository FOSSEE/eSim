* D:\FOSSEE\eSim\library\SubcircuitLibrary\LM143_IC\LM143_IC.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 07/13/24 18:26:26

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
I2  Net-_I2-Pad1_ Net-_I2-Pad2_ 80u
I3  Net-_I2-Pad1_ Net-_I3-Pad2_ 80u
I4  Net-_I2-Pad1_ Net-_I4-Pad2_ 80u
Q1  Net-_I2-Pad2_ Net-_Q1-Pad2_ Net-_I1-Pad1_ eSim_NPN
Q2  Net-_I1-Pad2_ Net-_I1-Pad1_ Net-_I2-Pad2_ eSim_PNP
Q6  Net-_I1-Pad2_ Net-_I5-Pad1_ Net-_I4-Pad2_ eSim_PNP
Q8  Net-_I4-Pad2_ Net-_Q8-Pad2_ Net-_I5-Pad1_ eSim_NPN
R2  Net-_Q3-Pad3_ Net-_I3-Pad2_ 5.6k
R3  Net-_I3-Pad2_ Net-_Q7-Pad3_ 5.6k
Q3  Net-_Q3-Pad1_ Net-_I1-Pad1_ Net-_Q3-Pad3_ eSim_PNP
Q7  Net-_C1-Pad2_ Net-_I5-Pad1_ Net-_Q7-Pad3_ eSim_PNP
Q4  Net-_Q3-Pad1_ Net-_Q3-Pad1_ Net-_I1-Pad2_ eSim_NPN
Q5  Net-_C1-Pad2_ Net-_Q3-Pad1_ Net-_I1-Pad2_ eSim_NPN
I1  Net-_I1-Pad1_ Net-_I1-Pad2_ 20u
I5  Net-_I5-Pad1_ Net-_I1-Pad2_ 20u
I6  Net-_I2-Pad1_ Net-_D1-Pad1_ 400u
D1  Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
D2  Net-_D1-Pad2_ Net-_D2-Pad2_ eSim_Diode
D3  Net-_D2-Pad2_ Net-_C1-Pad1_ eSim_Diode
Q11  Net-_C1-Pad1_ Net-_Q11-Pad2_ Net-_Q10-Pad1_ eSim_NPN
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 27p
Q9  Net-_I2-Pad1_ Net-_C1-Pad2_ Net-_Q10-Pad2_ eSim_NPN
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_I1-Pad2_ eSim_NPN
R5  Net-_Q10-Pad2_ Net-_I1-Pad2_ 39k
v1  Net-_Q11-Pad2_ Net-_I1-Pad2_ 2
Q15  Net-_I2-Pad1_ Net-_I7-Pad2_ Net-_Q13-Pad1_ eSim_NPN
Q13  Net-_Q13-Pad1_ Net-_D1-Pad1_ Net-_Q13-Pad3_ eSim_NPN
Q14  Net-_I1-Pad2_ Net-_Q12-Pad3_ Net-_Q13-Pad3_ eSim_PNP
Q12  Net-_I1-Pad2_ Net-_C1-Pad1_ Net-_Q12-Pad3_ eSim_PNP
I7  Net-_I2-Pad1_ Net-_I7-Pad2_ 400u
v2  Net-_I7-Pad2_ Net-_Q13-Pad3_ 3.5
U1  Net-_Q1-Pad2_ Net-_Q8-Pad2_ Net-_I1-Pad2_ Net-_Q13-Pad3_ Net-_I2-Pad1_ PORT

.end
