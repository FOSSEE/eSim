* D:\FOSSEE\eSim\library\SubcircuitLibrary\TL064_IC\TL064_IC.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 07/13/24 19:04:31

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
Q2  Net-_Q2-Pad1_ Net-_Q15-Pad2_ Net-_Q15-Pad3_ eSim_PNP
Q4  Net-_Q2-Pad1_ Net-_Q15-Pad2_ Net-_Q15-Pad3_ eSim_PNP
Q15  Net-_Q14-Pad1_ Net-_Q15-Pad2_ Net-_Q15-Pad3_ eSim_PNP
Q17  Net-_Q14-Pad1_ Net-_Q15-Pad2_ Net-_Q15-Pad3_ eSim_PNP
Q3  Net-_J1-Pad1_ Net-_Q3-Pad2_ Net-_Q2-Pad1_ eSim_PNP
J2  Net-_J1-Pad1_ Net-_J1-Pad2_ Net-_J1-Pad3_ jfet_p
J1  Net-_J1-Pad1_ Net-_J1-Pad2_ Net-_J1-Pad3_ jfet_p
J5  Net-_J1-Pad1_ Net-_J5-Pad2_ Net-_C1-Pad2_ jfet_p
J6  Net-_J1-Pad1_ Net-_J5-Pad2_ Net-_C1-Pad2_ jfet_p
Q1  Net-_J1-Pad3_ Net-_J1-Pad3_ Net-_Q1-Pad3_ eSim_NPN
Q6  Net-_C1-Pad2_ Net-_J1-Pad3_ Net-_Q6-Pad3_ eSim_NPN
R3  Net-_Q1-Pad3_ Net-_Q10-Pad3_ 34
R5  Net-_Q6-Pad3_ Net-_Q10-Pad3_ 35
Q14  Net-_Q14-Pad1_ Net-_Q14-Pad1_ Net-_Q14-Pad3_ eSim_NPN
R9  Net-_Q14-Pad1_ Net-_Q19-Pad1_ 220
R8  Net-_Q14-Pad3_ Net-_C1-Pad1_ 45k
Q13  Net-_C1-Pad1_ Net-_C1-Pad2_ Net-_Q10-Pad2_ eSim_NPN
Q16  Net-_C1-Pad1_ Net-_C1-Pad2_ Net-_Q10-Pad2_ eSim_NPN
Q19  Net-_Q19-Pad1_ Net-_Q14-Pad3_ Net-_C1-Pad1_ eSim_NPN
Q10  Net-_C1-Pad2_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 10p
R7  Net-_Q10-Pad2_ Net-_Q10-Pad3_ 7
Q26  Net-_Q15-Pad3_ Net-_Q19-Pad1_ Net-_Q25-Pad2_ eSim_NPN
Q29  Net-_Q15-Pad3_ Net-_Q19-Pad1_ Net-_Q25-Pad2_ eSim_NPN
R15  Net-_Q25-Pad2_ Net-_Q28-Pad3_ 270
Q28  Net-_Q10-Pad3_ Net-_C1-Pad1_ Net-_Q28-Pad3_ eSim_PNP
Q30  Net-_Q10-Pad3_ Net-_C1-Pad1_ Net-_Q28-Pad3_ eSim_PNP
R16  Net-_Q25-Pad3_ Net-_Q25-Pad2_ 64
Q25  Net-_Q19-Pad1_ Net-_Q25-Pad2_ Net-_Q25-Pad3_ eSim_NPN
Q39  Net-_J11-Pad2_ Net-_Q15-Pad2_ Net-_Q15-Pad3_ eSim_PNP
Q38  Net-_J9-Pad1_ Net-_J11-Pad1_ Net-_J11-Pad2_ eSim_PNP
Q41  Net-_J11-Pad1_ Net-_J11-Pad1_ Net-_J11-Pad2_ eSim_PNP
J9  Net-_J9-Pad1_ Net-_J11-Pad1_ Net-_J11-Pad3_ jfet_p
J11  Net-_J11-Pad1_ Net-_J11-Pad2_ Net-_J11-Pad3_ jfet_p
Q40  Net-_J11-Pad1_ Net-_Q35-Pad1_ Net-_Q10-Pad3_ eSim_NPN
Q42  Net-_J11-Pad1_ Net-_Q35-Pad1_ Net-_Q10-Pad3_ eSim_NPN
Q36  Net-_J11-Pad1_ Net-_Q35-Pad1_ Net-_Q10-Pad3_ eSim_NPN
R19  Net-_J11-Pad3_ Net-_Q35-Pad1_ 3.5k
Q35  Net-_Q35-Pad1_ Net-_J11-Pad3_ Net-_Q10-Pad3_ eSim_NPN
Q49  Net-_Q15-Pad2_ Net-_Q15-Pad2_ Net-_Q3-Pad2_ eSim_NPN
Q50  Net-_Q10-Pad3_ Net-_J11-Pad2_ Net-_Q3-Pad2_ eSim_PNP
Q7  Net-_Q7-Pad1_ Net-_Q21-Pad2_ Net-_Q15-Pad3_ eSim_PNP
Q9  Net-_Q7-Pad1_ Net-_Q21-Pad2_ Net-_Q15-Pad3_ eSim_PNP
Q21  Net-_Q20-Pad1_ Net-_Q21-Pad2_ Net-_Q15-Pad3_ eSim_PNP
Q23  Net-_Q20-Pad1_ Net-_Q21-Pad2_ Net-_Q15-Pad3_ eSim_PNP
Q8  Net-_J3-Pad1_ Net-_Q51-Pad3_ Net-_Q7-Pad1_ eSim_PNP
J4  Net-_J3-Pad1_ Net-_J3-Pad2_ Net-_J3-Pad3_ jfet_p
J3  Net-_J3-Pad1_ Net-_J3-Pad2_ Net-_J3-Pad3_ jfet_p
J7  Net-_J3-Pad1_ Net-_J7-Pad2_ Net-_C2-Pad2_ jfet_p
J8  Net-_J3-Pad1_ Net-_J7-Pad2_ Net-_C2-Pad2_ jfet_p
Q5  Net-_J3-Pad3_ Net-_J3-Pad3_ Net-_Q5-Pad3_ eSim_NPN
Q11  Net-_C2-Pad2_ Net-_J3-Pad3_ Net-_Q11-Pad3_ eSim_NPN
R4  Net-_Q5-Pad3_ Net-_Q10-Pad3_ 34
R6  Net-_Q11-Pad3_ Net-_Q10-Pad3_ 35
Q20  Net-_Q20-Pad1_ Net-_Q20-Pad1_ Net-_Q20-Pad3_ eSim_NPN
R12  Net-_Q20-Pad1_ Net-_Q24-Pad1_ 220
R11  Net-_Q20-Pad3_ Net-_C2-Pad1_ 45k
Q18  Net-_C2-Pad1_ Net-_C2-Pad2_ Net-_Q12-Pad2_ eSim_NPN
Q22  Net-_C2-Pad1_ Net-_C2-Pad2_ Net-_Q12-Pad2_ eSim_NPN
Q24  Net-_Q24-Pad1_ Net-_Q20-Pad3_ Net-_C2-Pad1_ eSim_NPN
Q12  Net-_C2-Pad2_ Net-_Q12-Pad2_ Net-_Q10-Pad3_ eSim_NPN
C2  Net-_C2-Pad1_ Net-_C2-Pad2_ 10p
R10  Net-_Q12-Pad2_ Net-_Q10-Pad3_ 7
Q31  Net-_Q15-Pad3_ Net-_Q24-Pad1_ Net-_Q27-Pad2_ eSim_NPN
Q33  Net-_Q15-Pad3_ Net-_Q24-Pad1_ Net-_Q27-Pad2_ eSim_NPN
R17  Net-_Q27-Pad2_ Net-_Q32-Pad3_ 270
Q32  Net-_Q10-Pad3_ Net-_C2-Pad1_ Net-_Q32-Pad3_ eSim_PNP
Q34  Net-_Q10-Pad3_ Net-_C2-Pad1_ Net-_Q32-Pad3_ eSim_PNP
R18  Net-_Q27-Pad3_ Net-_Q27-Pad2_ 64
Q27  Net-_Q24-Pad1_ Net-_Q27-Pad2_ Net-_Q27-Pad3_ eSim_NPN
Q45  Net-_J12-Pad2_ Net-_Q21-Pad2_ Net-_Q15-Pad3_ eSim_PNP
Q44  Net-_J10-Pad1_ Net-_J10-Pad2_ Net-_J12-Pad2_ eSim_PNP
Q47  Net-_J10-Pad2_ Net-_J10-Pad2_ Net-_J12-Pad2_ eSim_PNP
J10  Net-_J10-Pad1_ Net-_J10-Pad2_ Net-_J10-Pad3_ jfet_p
J12  Net-_J10-Pad2_ Net-_J12-Pad2_ Net-_J10-Pad3_ jfet_p
Q46  Net-_J10-Pad2_ Net-_Q37-Pad1_ Net-_Q10-Pad3_ eSim_NPN
Q48  Net-_J10-Pad2_ Net-_Q37-Pad1_ Net-_Q10-Pad3_ eSim_NPN
Q43  Net-_J10-Pad2_ Net-_Q37-Pad1_ Net-_Q10-Pad3_ eSim_NPN
R20  Net-_J10-Pad3_ Net-_Q37-Pad1_ 3.5k
Q37  Net-_Q37-Pad1_ Net-_J10-Pad3_ Net-_Q10-Pad3_ eSim_NPN
Q51  Net-_Q21-Pad2_ Net-_Q21-Pad2_ Net-_Q51-Pad3_ eSim_NPN
Q52  Net-_Q10-Pad3_ Net-_J12-Pad2_ Net-_Q51-Pad3_ eSim_PNP
U1  Net-_Q25-Pad3_ Net-_J1-Pad2_ Net-_J5-Pad2_ Net-_Q15-Pad3_ Net-_J7-Pad2_ Net-_J3-Pad2_ Net-_Q27-Pad3_ Net-_Q80-Pad3_ Net-_J15-Pad2_ Net-_J19-Pad2_ Net-_Q10-Pad3_ Net-_J16-Pad2_ Net-_J13-Pad2_ Net-_Q77-Pad3_ PORT
Q54  Net-_Q54-Pad1_ Net-_Q101-Pad1_ Net-_Q15-Pad3_ eSim_PNP
Q56  Net-_Q54-Pad1_ Net-_Q101-Pad1_ Net-_Q15-Pad3_ eSim_PNP
Q67  Net-_Q66-Pad1_ Net-_Q101-Pad1_ Net-_Q15-Pad3_ eSim_PNP
Q69  Net-_Q66-Pad1_ Net-_Q101-Pad1_ Net-_Q15-Pad3_ eSim_PNP
Q55  Net-_J13-Pad1_ Net-_Q101-Pad3_ Net-_Q54-Pad1_ eSim_PNP
J14  Net-_J13-Pad1_ Net-_J13-Pad2_ Net-_J13-Pad3_ jfet_p
J13  Net-_J13-Pad1_ Net-_J13-Pad2_ Net-_J13-Pad3_ jfet_p
J16  Net-_J13-Pad1_ Net-_J16-Pad2_ Net-_C3-Pad2_ jfet_p
J18  Net-_J13-Pad1_ Net-_J16-Pad2_ Net-_C3-Pad2_ jfet_p
Q53  Net-_J13-Pad3_ Net-_J13-Pad3_ Net-_Q53-Pad3_ eSim_NPN
Q58  Net-_C3-Pad2_ Net-_J13-Pad3_ Net-_Q58-Pad3_ eSim_NPN
R23  Net-_Q53-Pad3_ Net-_Q10-Pad3_ 34
R25  Net-_Q58-Pad3_ Net-_Q10-Pad3_ 35
Q66  Net-_Q66-Pad1_ Net-_Q66-Pad1_ Net-_Q66-Pad3_ eSim_NPN
R29  Net-_Q66-Pad1_ Net-_Q70-Pad1_ 220
R28  Net-_Q66-Pad3_ Net-_C3-Pad1_ 45k
Q65  Net-_C3-Pad1_ Net-_C3-Pad2_ Net-_Q62-Pad2_ eSim_NPN
Q68  Net-_C3-Pad1_ Net-_C3-Pad2_ Net-_Q62-Pad2_ eSim_NPN
Q70  Net-_Q70-Pad1_ Net-_Q66-Pad3_ Net-_C3-Pad1_ eSim_NPN
Q62  Net-_C3-Pad2_ Net-_Q62-Pad2_ Net-_Q10-Pad3_ eSim_NPN
C3  Net-_C3-Pad1_ Net-_C3-Pad2_ 10p
R27  Net-_Q62-Pad2_ Net-_Q10-Pad3_ 7
Q78  Net-_Q15-Pad3_ Net-_Q70-Pad1_ Net-_Q77-Pad2_ eSim_NPN
Q81  Net-_Q15-Pad3_ Net-_Q70-Pad1_ Net-_Q77-Pad2_ eSim_NPN
R34  Net-_Q77-Pad2_ Net-_Q79-Pad3_ 270
Q79  Net-_Q10-Pad3_ Net-_C3-Pad1_ Net-_Q79-Pad3_ eSim_PNP
Q82  Net-_Q10-Pad3_ Net-_C3-Pad1_ Net-_Q79-Pad3_ eSim_PNP
R36  Net-_Q77-Pad3_ Net-_Q77-Pad2_ 64
Q77  Net-_Q70-Pad1_ Net-_Q77-Pad2_ Net-_Q77-Pad3_ eSim_NPN
Q91  Net-_J23-Pad2_ Net-_Q101-Pad1_ Net-_Q15-Pad3_ eSim_PNP
Q89  Net-_J21-Pad1_ Net-_J21-Pad2_ Net-_J23-Pad2_ eSim_PNP
Q93  Net-_J21-Pad2_ Net-_J21-Pad2_ Net-_J23-Pad2_ eSim_PNP
J21  Net-_J21-Pad1_ Net-_J21-Pad2_ Net-_J21-Pad3_ jfet_p
J23  Net-_J21-Pad2_ Net-_J23-Pad2_ Net-_J21-Pad3_ jfet_p
Q92  Net-_J21-Pad2_ Net-_Q87-Pad1_ Net-_Q10-Pad3_ eSim_NPN
Q94  Net-_J21-Pad2_ Net-_Q87-Pad1_ Net-_Q10-Pad3_ eSim_NPN
Q88  Net-_J21-Pad2_ Net-_Q87-Pad1_ Net-_Q10-Pad3_ eSim_NPN
R39  Net-_J21-Pad3_ Net-_Q87-Pad1_ 3.5k
Q87  Net-_Q87-Pad1_ Net-_J21-Pad3_ Net-_Q10-Pad3_ eSim_NPN
Q101  Net-_Q101-Pad1_ Net-_Q101-Pad1_ Net-_Q101-Pad3_ eSim_NPN
Q102  Net-_Q10-Pad3_ Net-_J23-Pad2_ Net-_Q101-Pad3_ eSim_PNP
Q59  Net-_Q59-Pad1_ Net-_Q103-Pad1_ Net-_Q15-Pad3_ eSim_PNP
Q61  Net-_Q59-Pad1_ Net-_Q103-Pad1_ Net-_Q15-Pad3_ eSim_PNP
Q73  Net-_Q72-Pad1_ Net-_Q103-Pad1_ Net-_Q15-Pad3_ eSim_PNP
Q75  Net-_Q72-Pad1_ Net-_Q103-Pad1_ Net-_Q15-Pad3_ eSim_PNP
Q60  Net-_J15-Pad1_ Net-_Q103-Pad3_ Net-_Q59-Pad1_ eSim_PNP
J17  Net-_J15-Pad1_ Net-_J15-Pad2_ Net-_J15-Pad3_ jfet_p
J15  Net-_J15-Pad1_ Net-_J15-Pad2_ Net-_J15-Pad3_ jfet_p
J19  Net-_J15-Pad1_ Net-_J19-Pad2_ Net-_C4-Pad2_ jfet_p
J20  Net-_J15-Pad1_ Net-_J19-Pad2_ Net-_C4-Pad2_ jfet_p
Q57  Net-_J15-Pad3_ Net-_J15-Pad3_ Net-_Q57-Pad3_ eSim_NPN
Q63  Net-_C4-Pad2_ Net-_J15-Pad3_ Net-_Q63-Pad3_ eSim_NPN
R24  Net-_Q57-Pad3_ Net-_Q10-Pad3_ 34
R26  Net-_Q63-Pad3_ Net-_Q10-Pad3_ 35
Q72  Net-_Q72-Pad1_ Net-_Q72-Pad1_ Net-_Q72-Pad3_ eSim_NPN
R32  Net-_Q72-Pad1_ Net-_Q76-Pad1_ 220
R31  Net-_Q72-Pad3_ Net-_C4-Pad1_ 45k
Q71  Net-_C4-Pad1_ Net-_C4-Pad2_ Net-_Q64-Pad2_ eSim_NPN
Q74  Net-_C4-Pad1_ Net-_C4-Pad2_ Net-_Q64-Pad2_ eSim_NPN
Q76  Net-_Q76-Pad1_ Net-_Q72-Pad3_ Net-_C4-Pad1_ eSim_NPN
Q64  Net-_C4-Pad2_ Net-_Q64-Pad2_ Net-_Q10-Pad3_ eSim_NPN
C4  Net-_C4-Pad1_ Net-_C4-Pad2_ 10p
R30  Net-_Q64-Pad2_ Net-_Q10-Pad3_ 7
Q83  Net-_Q15-Pad3_ Net-_Q76-Pad1_ Net-_Q80-Pad2_ eSim_NPN
Q85  Net-_Q15-Pad3_ Net-_Q76-Pad1_ Net-_Q80-Pad2_ eSim_NPN
R37  Net-_Q80-Pad2_ Net-_Q84-Pad3_ 270
Q84  Net-_Q10-Pad3_ Net-_C4-Pad1_ Net-_Q84-Pad3_ eSim_PNP
Q86  Net-_Q10-Pad3_ Net-_C4-Pad1_ Net-_Q84-Pad3_ eSim_PNP
R38  Net-_Q80-Pad3_ Net-_Q80-Pad2_ 64
Q80  Net-_Q76-Pad1_ Net-_Q80-Pad2_ Net-_Q80-Pad3_ eSim_NPN
Q97  Net-_J24-Pad2_ Net-_Q103-Pad1_ Net-_Q15-Pad3_ eSim_PNP
Q96  Net-_J22-Pad1_ Net-_J22-Pad2_ Net-_J24-Pad2_ eSim_PNP
Q99  Net-_J22-Pad2_ Net-_J22-Pad2_ Net-_J24-Pad2_ eSim_PNP
J22  Net-_J22-Pad1_ Net-_J22-Pad2_ Net-_J22-Pad3_ jfet_p
J24  Net-_J22-Pad2_ Net-_J24-Pad2_ Net-_J22-Pad3_ jfet_p
Q98  Net-_J22-Pad2_ Net-_Q100-Pad2_ Net-_Q10-Pad3_ eSim_NPN
Q100  Net-_J22-Pad2_ Net-_Q100-Pad2_ Net-_Q10-Pad3_ eSim_NPN
Q95  Net-_J22-Pad2_ Net-_Q100-Pad2_ Net-_Q10-Pad3_ eSim_NPN
R40  Net-_J22-Pad3_ Net-_Q100-Pad2_ 3.5k
Q90  Net-_Q100-Pad2_ Net-_J22-Pad3_ Net-_Q10-Pad3_ eSim_NPN
Q103  Net-_Q103-Pad1_ Net-_Q103-Pad1_ Net-_Q103-Pad3_ eSim_NPN
Q104  Net-_Q10-Pad3_ Net-_J24-Pad2_ Net-_Q103-Pad3_ eSim_PNP

.end
