* C:\FOSSEE\eSim\library\SubcircuitLibrary\CA3140_sub\CA3140_sub.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 18/06/2024 3:54:31 PM

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
Q1  Net-_Q1-Pad1_ Net-_D1-Pad2_ Net-_D1-Pad1_ eSim_PNP
Q3  Net-_M1-Pad3_ Net-_Q1-Pad1_ Net-_D1-Pad2_ eSim_PNP
Q2  Net-_Q1-Pad1_ Net-_M1-Pad3_ Net-_Q2-Pad3_ eSim_NPN
M1  Net-_D2-Pad1_ Net-_D2-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad3_ mosfet_p
R1  Net-_D2-Pad2_ Net-_Q2-Pad3_ 8K
D2  Net-_D2-Pad1_ Net-_D2-Pad2_ eSim_Diode
U2  Net-_U2-PadIN_ Net-_M2-Pad2_ zener
U4  Net-_U2-PadIN_ Net-_M3-Pad2_ zener
U3  Net-_U2-PadIN_ Net-_M2-Pad3_ zener
M2  Net-_M2-Pad1_ Net-_M2-Pad2_ Net-_M2-Pad3_ Net-_M2-Pad3_ mosfet_p
M3  Net-_M3-Pad1_ Net-_M3-Pad2_ Net-_M2-Pad3_ Net-_M2-Pad3_ mosfet_p
R2  Net-_Q4-Pad1_ Net-_M2-Pad1_ 500
R4  Net-_C1-Pad1_ Net-_M3-Pad1_ 500
R3  Net-_D2-Pad2_ Net-_Q4-Pad3_ 500
R5  Net-_D2-Pad2_ Net-_Q7-Pad3_ 500
Q4  Net-_Q4-Pad1_ Net-_M2-Pad1_ Net-_Q4-Pad3_ eSim_NPN
Q7  Net-_C1-Pad1_ Net-_M2-Pad1_ Net-_Q7-Pad3_ eSim_NPN
Q6  Net-_M2-Pad3_ Net-_Q1-Pad1_ Net-_Q5-Pad1_ eSim_PNP
Q5  Net-_Q5-Pad1_ Net-_D1-Pad2_ Net-_D1-Pad1_ eSim_PNP
Q8  Net-_Q13-Pad1_ Net-_D1-Pad2_ Net-_D1-Pad1_ eSim_PNP
Q9  Net-_C1-Pad2_ Net-_Q1-Pad1_ Net-_Q13-Pad1_ eSim_PNP
Q13  Net-_Q13-Pad1_ Net-_Q13-Pad2_ Net-_Q13-Pad3_ eSim_NPN
Q11  Net-_D1-Pad1_ Net-_C1-Pad2_ Net-_Q11-Pad3_ eSim_NPN
Q12  Net-_Q11-Pad3_ Net-_D2-Pad1_ Net-_Q12-Pad3_ eSim_NPN
Q14  Net-_M4-Pad2_ Net-_D2-Pad1_ Net-_D2-Pad2_ eSim_NPN
Q16  Net-_M4-Pad2_ Net-_D4-Pad1_ Net-_D2-Pad2_ eSim_NPN
R6  Net-_D2-Pad2_ Net-_Q12-Pad3_ 50
R12  Net-_D2-Pad2_ Net-_D4-Pad2_ 30
R7  Net-_Q11-Pad3_ Net-_Q15-Pad2_ 1K
R8  Net-_Q13-Pad2_ Net-_R10-Pad2_ 1K
R10  Net-_Q13-Pad3_ Net-_R10-Pad2_ 20
R9  Net-_D3-Pad2_ Net-_R10-Pad2_ 50
D4  Net-_D4-Pad1_ Net-_D4-Pad2_ eSim_Diode
D3  Net-_D1-Pad1_ Net-_D3-Pad2_ eSim_Diode
Q17  Net-_D1-Pad1_ Net-_Q17-Pad2_ Net-_Q17-Pad3_ eSim_NPN
R13  Net-_Q17-Pad2_ Net-_D1-Pad1_ 5K
R14  Net-_D2-Pad2_ Net-_R14-Pad2_ 20K
R11  Net-_M4-Pad3_ Net-_Q17-Pad3_ 12K
M4  Net-_D4-Pad1_ Net-_M4-Pad2_ Net-_M4-Pad3_ Net-_M4-Pad3_ mosfet_p
U5  Net-_R14-Pad2_ Net-_Q17-Pad2_ zener
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 12pF
Q10  Net-_C1-Pad2_ Net-_C1-Pad1_ Net-_D2-Pad2_ eSim_NPN
D1  Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
Q15  Net-_Q13-Pad3_ Net-_Q15-Pad2_ Net-_M4-Pad2_ eSim_NPN
U1  Net-_Q7-Pad3_ Net-_M2-Pad2_ Net-_M3-Pad2_ Net-_D2-Pad2_ Net-_Q4-Pad3_ Net-_M4-Pad2_ Net-_D1-Pad1_ Net-_C1-Pad2_ PORT

.end
