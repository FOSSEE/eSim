* C:\FOSSEE\eSim\library\SubcircuitLibrary\LM2901_Sub\LM2901_Sub.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 09/10/24 18:12:35

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
D3  Net-_D3-Pad1_ Net-_D1-Pad1_ eSim_Diode
D1  Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
Q1  Net-_Q1-Pad1_ Net-_D1-Pad2_ Net-_D1-Pad1_ eSim_PNP
Q3  Net-_Q3-Pad1_ Net-_D1-Pad1_ Net-_I3-Pad2_ eSim_PNP
I1  Net-_I1-Pad1_ Net-_D3-Pad1_ 80u
I3  Net-_I1-Pad1_ Net-_I3-Pad2_ 80u
I5  Net-_I1-Pad1_ Net-_D5-Pad1_ 80u
Q8  Net-_Q13-Pad2_ Net-_D5-Pad2_ Net-_I3-Pad2_ eSim_PNP
D5  Net-_D5-Pad1_ Net-_D5-Pad2_ eSim_Diode
D7  Net-_D7-Pad1_ Net-_D5-Pad2_ eSim_Diode
Q11  GND Net-_D7-Pad1_ Net-_D5-Pad2_ eSim_PNP
Q4  Net-_Q3-Pad1_ Net-_Q3-Pad1_ Net-_Q1-Pad1_ eSim_NPN
Q7  Net-_Q13-Pad2_ Net-_Q3-Pad1_ Net-_Q1-Pad1_ eSim_NPN
I7  Net-_I1-Pad1_ Net-_I7-Pad2_ 80u
Q13  Net-_I7-Pad2_ Net-_Q13-Pad2_ Net-_Q1-Pad1_ eSim_NPN
Q15  Net-_Q15-Pad1_ Net-_I7-Pad2_ Net-_Q1-Pad1_ eSim_NPN
R1  Net-_I1-Pad1_ Net-_Q15-Pad1_ 18k
D12  Net-_D12-Pad1_ Net-_D10-Pad1_ eSim_Diode
D10  Net-_D10-Pad1_ Net-_D10-Pad2_ eSim_Diode
Q18  Net-_Q1-Pad1_ Net-_D10-Pad2_ Net-_D10-Pad1_ eSim_PNP
Q20  Net-_Q20-Pad1_ Net-_D10-Pad1_ Net-_I12-Pad2_ eSim_PNP
I10  Net-_I1-Pad1_ Net-_D12-Pad1_ 80u
I12  Net-_I1-Pad1_ Net-_I12-Pad2_ 80u
I14  Net-_I1-Pad1_ Net-_D14-Pad1_ 80u
Q26  Net-_Q24-Pad1_ Net-_D14-Pad2_ Net-_I12-Pad2_ eSim_PNP
D14  Net-_D14-Pad1_ Net-_D14-Pad2_ eSim_Diode
D16  Net-_D16-Pad1_ Net-_D14-Pad2_ eSim_Diode
Q28  GND Net-_D16-Pad1_ Net-_D14-Pad2_ eSim_PNP
Q22  Net-_Q20-Pad1_ Net-_Q20-Pad1_ Net-_Q1-Pad1_ eSim_NPN
Q24  Net-_Q24-Pad1_ Net-_Q20-Pad1_ Net-_Q1-Pad1_ eSim_NPN
I16  Net-_I1-Pad1_ Net-_I16-Pad2_ 80u
Q30  Net-_I16-Pad2_ Net-_Q24-Pad1_ Net-_Q1-Pad1_ eSim_NPN
Q32  Net-_Q32-Pad1_ Net-_I16-Pad2_ Net-_Q1-Pad1_ eSim_NPN
R4  Net-_I1-Pad1_ Net-_Q32-Pad1_ 18k
D4  Net-_D4-Pad1_ Net-_D2-Pad1_ eSim_Diode
D2  Net-_D2-Pad1_ Net-_D2-Pad2_ eSim_Diode
Q2  Net-_Q1-Pad1_ Net-_D2-Pad2_ Net-_D2-Pad1_ eSim_PNP
Q5  Net-_Q5-Pad1_ Net-_D2-Pad1_ Net-_I4-Pad2_ eSim_PNP
I2  Net-_I1-Pad1_ Net-_D4-Pad1_ 80u
I4  Net-_I1-Pad1_ Net-_I4-Pad2_ 80u
I6  Net-_I1-Pad1_ Net-_D6-Pad1_ 80u
Q10  Net-_Q10-Pad1_ Net-_D6-Pad2_ Net-_I4-Pad2_ eSim_PNP
D6  Net-_D6-Pad1_ Net-_D6-Pad2_ eSim_Diode
D8  Net-_D8-Pad1_ Net-_D6-Pad2_ eSim_Diode
Q12  GND Net-_D8-Pad1_ Net-_D6-Pad2_ eSim_PNP
Q6  Net-_Q5-Pad1_ Net-_Q5-Pad1_ Net-_Q1-Pad1_ eSim_NPN
Q9  Net-_Q10-Pad1_ Net-_Q5-Pad1_ Net-_Q1-Pad1_ eSim_NPN
I8  Net-_I1-Pad1_ Net-_I8-Pad2_ 80u
Q14  Net-_I8-Pad2_ Net-_Q10-Pad1_ Net-_Q1-Pad1_ eSim_NPN
Q16  Net-_Q16-Pad1_ Net-_I8-Pad2_ Net-_Q1-Pad1_ eSim_NPN
R2  Net-_I1-Pad1_ Net-_Q16-Pad1_ 18k
D11  Net-_D11-Pad1_ Net-_D11-Pad2_ eSim_Diode
D9  Net-_D11-Pad2_ Net-_D9-Pad2_ eSim_Diode
Q17  Net-_Q1-Pad1_ Net-_D9-Pad2_ Net-_D11-Pad2_ eSim_PNP
Q19  Net-_Q19-Pad1_ Net-_D11-Pad2_ Net-_I11-Pad2_ eSim_PNP
I9  Net-_I1-Pad1_ Net-_D11-Pad1_ 80u
I11  Net-_I1-Pad1_ Net-_I11-Pad2_ 80u
I13  Net-_I1-Pad1_ Net-_D13-Pad1_ 80u
Q25  Net-_Q23-Pad1_ Net-_D13-Pad2_ Net-_I11-Pad2_ eSim_PNP
D13  Net-_D13-Pad1_ Net-_D13-Pad2_ eSim_Diode
D15  Net-_D15-Pad1_ Net-_D13-Pad2_ eSim_Diode
Q27  GND Net-_D15-Pad1_ Net-_D13-Pad2_ eSim_PNP
Q21  Net-_Q19-Pad1_ Net-_Q19-Pad1_ Net-_Q1-Pad1_ eSim_NPN
Q23  Net-_Q23-Pad1_ Net-_Q19-Pad1_ Net-_Q1-Pad1_ eSim_NPN
I15  Net-_I1-Pad1_ Net-_I15-Pad2_ 80u
Q29  Net-_I15-Pad2_ Net-_Q23-Pad1_ Net-_Q1-Pad1_ eSim_NPN
Q31  Net-_Q31-Pad1_ Net-_I15-Pad2_ Net-_Q1-Pad1_ eSim_NPN
R3  Net-_I1-Pad1_ Net-_Q31-Pad1_ 18k
U1  Net-_Q15-Pad1_ Net-_Q32-Pad1_ Net-_I1-Pad1_ Net-_D16-Pad1_ Net-_D10-Pad2_ Net-_D7-Pad1_ Net-_D1-Pad2_ Net-_D8-Pad1_ Net-_D2-Pad2_ Net-_D15-Pad1_ Net-_D9-Pad2_ Net-_Q1-Pad1_ Net-_Q31-Pad1_ Net-_Q16-Pad1_ PORT

.end
