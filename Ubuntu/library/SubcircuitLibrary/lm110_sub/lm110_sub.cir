* C:\FOSSEE\eSim\library\SubcircuitLibrary\lm110_sub\lm110_sub.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 30/05/2024 10:59:26 AM

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad1_ Net-_J1-Pad2_ eSim_NPN
Q3  Net-_Q3-Pad1_ Net-_J1-Pad3_ Net-_Q3-Pad3_ eSim_NPN
Q2  Net-_Q14-Pad2_ Net-_Q1-Pad1_ Net-_J1-Pad3_ eSim_PNP
R2  Net-_J1-Pad2_ Net-_Q3-Pad3_ 3k
R8  Net-_J1-Pad2_ Net-_Q9-Pad3_ 1.5k
Q9  Net-_Q12-Pad3_ Net-_J1-Pad3_ Net-_Q9-Pad3_ eSim_NPN
Q14  Net-_Q11-Pad1_ Net-_Q14-Pad2_ Net-_Q14-Pad3_ eSim_NPN
R11  Net-_J1-Pad2_ Net-_Q14-Pad3_ 200
Q11  Net-_Q11-Pad1_ Net-_Q11-Pad1_ Net-_D1-Pad1_ eSim_NPN
J1  Net-_J1-Pad1_ Net-_J1-Pad2_ Net-_J1-Pad3_ jfet_n
Q12  Net-_Q12-Pad1_ Net-_Q12-Pad1_ Net-_Q12-Pad3_ eSim_NPN
Q8  Net-_D1-Pad2_ Net-_Q7-Pad3_ Net-_Q10-Pad3_ eSim_NPN
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
Q7  Net-_D1-Pad2_ Net-_D1-Pad1_ Net-_Q7-Pad3_ eSim_NPN
Q13  Net-_Q10-Pad1_ Net-_C1-Pad2_ Net-_Q10-Pad2_ eSim_NPN
R6  Net-_Q12-Pad1_ Net-_Q7-Pad3_ 200k
R9  Net-_Q12-Pad1_ Net-_Q10-Pad2_ 200k
R10  Net-_C1-Pad2_ Net-_Q11-Pad1_ 5k
R13  Net-_Q11-Pad1_ Net-_D1-Pad2_ 25
R12  Net-_D1-Pad2_ Net-_Q15-Pad2_ 3k
Q15  Net-_C1-Pad1_ Net-_Q15-Pad2_ Net-_Q10-Pad1_ eSim_NPN
Q17  Net-_J1-Pad1_ Net-_C1-Pad1_ Net-_Q15-Pad2_ eSim_NPN
Q18  Net-_J1-Pad1_ Net-_Q15-Pad2_ Net-_D1-Pad2_ eSim_NPN
Q16  Net-_C1-Pad1_ Net-_D1-Pad2_ Net-_Q11-Pad1_ eSim_NPN
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 10pF
Q4  Net-_Q3-Pad1_ Net-_Q4-Pad2_ Net-_Q4-Pad3_ eSim_PNP
Q5  Net-_Q4-Pad2_ Net-_Q4-Pad2_ Net-_Q5-Pad3_ eSim_PNP
Q6  Net-_C1-Pad1_ Net-_Q3-Pad1_ Net-_Q4-Pad2_ eSim_PNP
R3  Net-_R1-Pad2_ Net-_J1-Pad1_ 500
R4  Net-_J1-Pad1_ Net-_R4-Pad2_ 500
R5  Net-_Q5-Pad3_ Net-_R4-Pad2_ 1k
D1  Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
R1  Net-_Q4-Pad3_ Net-_R1-Pad2_ 1k
R7  Net-_Q12-Pad3_ Net-_Q10-Pad3_ 150
U1  Net-_R1-Pad2_ Net-_R4-Pad2_ Net-_D1-Pad1_ Net-_J1-Pad2_ Net-_Q14-Pad3_ Net-_Q11-Pad1_ Net-_J1-Pad1_ PORT

.end
