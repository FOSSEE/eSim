* C:\FOSSEE\eSim\library\SubcircuitLibrary\MC74HC238\MC74HC238.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/04/24 07:37:01

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U37  Net-_U21-Pad2_ Net-_U22-Pad2_ Net-_U1-Pad7_ d_and
U21  Net-_U18-Pad2_ Net-_U21-Pad2_ d_inverter
U22  Net-_U17-Pad3_ Net-_U22-Pad2_ d_inverter
U38  Net-_U23-Pad2_ Net-_U24-Pad2_ Net-_U1-Pad8_ d_and
U23  Net-_U19-Pad2_ Net-_U23-Pad2_ d_inverter
U24  Net-_U17-Pad3_ Net-_U24-Pad2_ d_inverter
U39  Net-_U25-Pad2_ Net-_U26-Pad2_ Net-_U1-Pad9_ d_and
U25  Net-_U20-Pad2_ Net-_U25-Pad2_ d_inverter
U26  Net-_U17-Pad3_ Net-_U26-Pad2_ d_inverter
U40  Net-_U27-Pad2_ Net-_U28-Pad2_ Net-_U1-Pad10_ d_and
U27  Net-_U27-Pad1_ Net-_U27-Pad2_ d_inverter
U28  Net-_U17-Pad3_ Net-_U28-Pad2_ d_inverter
U41  Net-_U29-Pad2_ Net-_U30-Pad2_ Net-_U1-Pad11_ d_and
U29  Net-_U29-Pad1_ Net-_U29-Pad2_ d_inverter
U30  Net-_U17-Pad3_ Net-_U30-Pad2_ d_inverter
U42  Net-_U31-Pad2_ Net-_U32-Pad2_ Net-_U1-Pad12_ d_and
U31  Net-_U31-Pad1_ Net-_U31-Pad2_ d_inverter
U32  Net-_U17-Pad3_ Net-_U32-Pad2_ d_inverter
U43  Net-_U33-Pad2_ Net-_U34-Pad2_ Net-_U1-Pad13_ d_and
U33  Net-_U33-Pad1_ Net-_U33-Pad2_ d_inverter
U34  Net-_U17-Pad3_ Net-_U34-Pad2_ d_inverter
U44  Net-_U35-Pad2_ Net-_U36-Pad2_ Net-_U1-Pad14_ d_and
U35  Net-_U35-Pad1_ Net-_U35-Pad2_ d_inverter
U36  Net-_U17-Pad3_ Net-_U36-Pad2_ d_inverter
U10  Net-_U1-Pad1_ Net-_U10-Pad2_ d_inverter
U11  Net-_U1-Pad2_ Net-_U11-Pad2_ d_inverter
U12  Net-_U1-Pad3_ Net-_U12-Pad2_ d_inverter
U14  Net-_U10-Pad2_ Net-_U14-Pad2_ d_inverter
U15  Net-_U11-Pad2_ Net-_U15-Pad2_ d_inverter
U16  Net-_U12-Pad2_ Net-_U16-Pad2_ d_inverter
U17  Net-_U13-Pad3_ Net-_U1-Pad6_ Net-_U17-Pad3_ d_nand
U13  Net-_U13-Pad1_ Net-_U13-Pad2_ Net-_U13-Pad3_ d_and
U8  Net-_U1-Pad4_ Net-_U13-Pad1_ d_inverter
U9  Net-_U1-Pad5_ Net-_U13-Pad2_ d_inverter
X1  Net-_U10-Pad2_ Net-_U11-Pad2_ Net-_U12-Pad2_ Net-_U18-Pad1_ 3_and
X2  Net-_U14-Pad2_ Net-_U11-Pad2_ Net-_U12-Pad2_ Net-_U19-Pad1_ 3_and
X3  Net-_U10-Pad2_ Net-_U15-Pad2_ Net-_U12-Pad2_ Net-_U20-Pad1_ 3_and
X4  Net-_U14-Pad2_ Net-_U15-Pad2_ Net-_U12-Pad2_ Net-_U54-Pad1_ 3_and
X5  Net-_U10-Pad2_ Net-_U11-Pad2_ Net-_U16-Pad2_ Net-_U55-Pad1_ 3_and
X6  Net-_U11-Pad2_ Net-_U16-Pad2_ Net-_U10-Pad2_ Net-_U56-Pad1_ 3_and
X8  Net-_U14-Pad2_ Net-_U15-Pad2_ Net-_U16-Pad2_ Net-_U58-Pad1_ 3_and
X7  Net-_U10-Pad2_ Net-_U15-Pad2_ Net-_U16-Pad2_ Net-_U57-Pad1_ 3_and
U18  Net-_U18-Pad1_ Net-_U18-Pad2_ d_inverter
U19  Net-_U19-Pad1_ Net-_U19-Pad2_ d_inverter
U20  Net-_U20-Pad1_ Net-_U20-Pad2_ d_inverter
U54  Net-_U54-Pad1_ Net-_U27-Pad1_ d_inverter
U55  Net-_U55-Pad1_ Net-_U29-Pad1_ d_inverter
U56  Net-_U56-Pad1_ Net-_U31-Pad1_ d_inverter
U57  Net-_U57-Pad1_ Net-_U33-Pad1_ d_inverter
U58  Net-_U58-Pad1_ Net-_U35-Pad1_ d_inverter
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ PORT

.end
