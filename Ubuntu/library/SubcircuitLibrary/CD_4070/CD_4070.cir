* C:\FOSSEE\eSim\library\SubcircuitLibrary\CD_4070\CD_4070.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 05/29/22 16:05:10

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
M21  Net-_M13-Pad2_ Net-_M14-Pad2_ Net-_M11-Pad3_ Net-_M11-Pad3_ eSim_MOS_P
M25  Net-_M13-Pad2_ Net-_M14-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad3_ eSim_MOS_N
M9  Net-_M10-Pad3_ Net-_M1-Pad2_ Net-_M11-Pad3_ Net-_M11-Pad3_ eSim_MOS_P
M13  Net-_M10-Pad3_ Net-_M13-Pad2_ Net-_M11-Pad3_ Net-_M11-Pad3_ eSim_MOS_P
M10  Net-_M10-Pad1_ Net-_M1-Pad1_ Net-_M10-Pad3_ Net-_M10-Pad3_ eSim_MOS_P
M14  Net-_M10-Pad1_ Net-_M14-Pad2_ Net-_M10-Pad3_ Net-_M10-Pad3_ eSim_MOS_P
M3  Net-_M1-Pad1_ Net-_M1-Pad2_ Net-_M11-Pad3_ Net-_M11-Pad3_ eSim_MOS_P
M1  Net-_M1-Pad1_ Net-_M1-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad3_ eSim_MOS_N
M5  Net-_M10-Pad1_ Net-_M1-Pad2_ Net-_M5-Pad3_ Net-_M5-Pad3_ eSim_MOS_N
M6  Net-_M5-Pad3_ Net-_M13-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad3_ eSim_MOS_N
M17  Net-_M10-Pad1_ Net-_M1-Pad1_ Net-_M17-Pad3_ Net-_M17-Pad3_ eSim_MOS_N
M18  Net-_M17-Pad3_ Net-_M14-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad3_ eSim_MOS_N
M50  Net-_M34-Pad2_ Net-_M42-Pad2_ Net-_M11-Pad3_ Net-_M11-Pad3_ eSim_MOS_P
M54  Net-_M34-Pad2_ Net-_M42-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad3_ eSim_MOS_N
M37  Net-_M37-Pad1_ Net-_M29-Pad2_ Net-_M11-Pad3_ Net-_M11-Pad3_ eSim_MOS_P
M41  Net-_M37-Pad1_ Net-_M34-Pad2_ Net-_M11-Pad3_ Net-_M11-Pad3_ eSim_MOS_P
M38  Net-_M33-Pad1_ Net-_M29-Pad1_ Net-_M37-Pad1_ Net-_M37-Pad1_ eSim_MOS_P
M42  Net-_M33-Pad1_ Net-_M42-Pad2_ Net-_M37-Pad1_ Net-_M37-Pad1_ eSim_MOS_P
M31  Net-_M29-Pad1_ Net-_M29-Pad2_ Net-_M11-Pad3_ Net-_M11-Pad3_ eSim_MOS_P
M29  Net-_M29-Pad1_ Net-_M29-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad3_ eSim_MOS_N
M33  Net-_M33-Pad1_ Net-_M29-Pad2_ Net-_M33-Pad3_ Net-_M33-Pad3_ eSim_MOS_N
M34  Net-_M33-Pad3_ Net-_M34-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad3_ eSim_MOS_N
M45  Net-_M33-Pad1_ Net-_M29-Pad1_ Net-_M45-Pad3_ Net-_M45-Pad3_ eSim_MOS_N
M46  Net-_M45-Pad3_ Net-_M42-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad3_ eSim_MOS_N
M23  Net-_M15-Pad2_ Net-_M16-Pad2_ Net-_M11-Pad3_ Net-_M11-Pad3_ eSim_MOS_P
M27  Net-_M15-Pad2_ Net-_M16-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad3_ eSim_MOS_N
M11  Net-_M11-Pad1_ Net-_M11-Pad2_ Net-_M11-Pad3_ Net-_M11-Pad3_ eSim_MOS_P
M15  Net-_M11-Pad1_ Net-_M15-Pad2_ Net-_M11-Pad3_ Net-_M11-Pad3_ eSim_MOS_P
M12  Net-_M12-Pad1_ Net-_M12-Pad2_ Net-_M11-Pad1_ Net-_M11-Pad1_ eSim_MOS_P
M16  Net-_M12-Pad1_ Net-_M16-Pad2_ Net-_M11-Pad1_ Net-_M11-Pad1_ eSim_MOS_P
M4  Net-_M12-Pad2_ Net-_M11-Pad2_ Net-_M11-Pad3_ Net-_M11-Pad3_ eSim_MOS_P
M2  Net-_M12-Pad2_ Net-_M11-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad3_ eSim_MOS_N
M7  Net-_M12-Pad1_ Net-_M11-Pad2_ Net-_M7-Pad3_ Net-_M7-Pad3_ eSim_MOS_N
M8  Net-_M7-Pad3_ Net-_M15-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad3_ eSim_MOS_N
M19  Net-_M12-Pad1_ Net-_M12-Pad2_ Net-_M19-Pad3_ Net-_M19-Pad3_ eSim_MOS_N
M20  Net-_M19-Pad3_ Net-_M16-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad3_ eSim_MOS_N
M52  Net-_M36-Pad2_ Net-_M44-Pad2_ Net-_M11-Pad3_ Net-_M11-Pad3_ eSim_MOS_P
M56  Net-_M36-Pad2_ Net-_M44-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad3_ eSim_MOS_N
M39  Net-_M39-Pad1_ Net-_M30-Pad2_ Net-_M11-Pad3_ Net-_M11-Pad3_ eSim_MOS_P
M43  Net-_M39-Pad1_ Net-_M36-Pad2_ Net-_M11-Pad3_ Net-_M11-Pad3_ eSim_MOS_P
M40  Net-_M35-Pad1_ Net-_M30-Pad1_ Net-_M39-Pad1_ Net-_M39-Pad1_ eSim_MOS_P
M44  Net-_M35-Pad1_ Net-_M44-Pad2_ Net-_M39-Pad1_ Net-_M39-Pad1_ eSim_MOS_P
M32  Net-_M30-Pad1_ Net-_M30-Pad2_ Net-_M11-Pad3_ Net-_M11-Pad3_ eSim_MOS_P
M30  Net-_M30-Pad1_ Net-_M30-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad3_ eSim_MOS_N
M35  Net-_M35-Pad1_ Net-_M30-Pad2_ Net-_M35-Pad3_ Net-_M35-Pad3_ eSim_MOS_N
M36  Net-_M35-Pad3_ Net-_M36-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad3_ eSim_MOS_N
M47  Net-_M35-Pad1_ Net-_M30-Pad1_ Net-_M47-Pad3_ Net-_M47-Pad3_ eSim_MOS_N
M48  Net-_M47-Pad3_ Net-_M44-Pad2_ Net-_M1-Pad3_ Net-_M1-Pad3_ eSim_MOS_N
M26  Net-_M22-Pad1_ Net-_M10-Pad1_ Net-_M11-Pad3_ Net-_M11-Pad3_ eSim_MOS_P
M22  Net-_M22-Pad1_ Net-_M10-Pad1_ Net-_M1-Pad3_ Net-_M1-Pad3_ eSim_MOS_N
M28  Net-_M24-Pad1_ Net-_M12-Pad1_ Net-_M11-Pad3_ Net-_M11-Pad3_ eSim_MOS_P
M24  Net-_M24-Pad1_ Net-_M12-Pad1_ Net-_M1-Pad3_ Net-_M1-Pad3_ eSim_MOS_N
M53  Net-_M49-Pad1_ Net-_M35-Pad1_ Net-_M11-Pad3_ Net-_M11-Pad3_ eSim_MOS_P
M49  Net-_M49-Pad1_ Net-_M35-Pad1_ Net-_M1-Pad3_ Net-_M1-Pad3_ eSim_MOS_N
M55  Net-_M51-Pad1_ Net-_M33-Pad1_ Net-_M11-Pad3_ Net-_M11-Pad3_ eSim_MOS_P
M51  Net-_M51-Pad1_ Net-_M33-Pad1_ Net-_M1-Pad3_ Net-_M1-Pad3_ eSim_MOS_N
U1  Net-_M11-Pad2_ Net-_M16-Pad2_ Net-_M24-Pad1_ Net-_M49-Pad1_ Net-_M30-Pad2_ Net-_M44-Pad2_ Net-_M1-Pad3_ Net-_M29-Pad2_ Net-_M42-Pad2_ Net-_M51-Pad1_ Net-_M22-Pad1_ Net-_M1-Pad2_ Net-_M14-Pad2_ Net-_M11-Pad3_ PORT

.end
