* C:\FOSSEE\eSim\library\SubcircuitLibrary\SN7432_Subcirrcuit\SN7432_Subcirrcuit.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 01/10/25 23:23:51

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
Q3  Net-_Q3-Pad1_ Net-_Q3-Pad2_ Net-_D2-Pad2_ eSim_NPN
Q4  Net-_Q4-Pad1_ Net-_Q4-Pad2_ Net-_D4-Pad2_ eSim_NPN
Q7  Net-_D6-Pad1_ Net-_Q3-Pad1_ Net-_Q10-Pad2_ eSim_NPN
Q8  Net-_D6-Pad1_ Net-_Q4-Pad1_ Net-_Q10-Pad2_ eSim_NPN
D6  Net-_D6-Pad1_ Net-_D6-Pad2_ eSim_Diode
R2  Net-_R1-Pad1_ Net-_Q3-Pad2_ 4k
R4  Net-_R1-Pad1_ Net-_Q4-Pad2_ 2k
R7  Net-_R1-Pad1_ Net-_D6-Pad1_ 2.5k
Q10  Net-_D6-Pad2_ Net-_Q10-Pad2_ GNDPWR eSim_NPN
Q12  Net-_Q12-Pad1_ Net-_D6-Pad2_ Net-_Q12-Pad3_ eSim_NPN
Q15  Net-_Q15-Pad1_ Net-_Q12-Pad1_ Net-_D8-Pad1_ eSim_NPN
R11  Net-_R1-Pad1_ Net-_Q12-Pad1_ 1.6k
R14  Net-_R1-Pad1_ Net-_Q15-Pad1_ 130
D4  GNDPWR Net-_D4-Pad2_ eSim_Diode
D2  GNDPWR Net-_D2-Pad2_ eSim_Diode
R8  Net-_Q10-Pad2_ GNDPWR 1k
R12  Net-_Q12-Pad3_ GNDPWR 1k
D8  Net-_D8-Pad1_ Net-_D8-Pad2_ eSim_Diode
Q16  Net-_D8-Pad2_ Net-_Q12-Pad3_ GNDPWR eSim_NPN
Q29  Net-_Q25-Pad2_ Net-_Q29-Pad2_ Net-_D15-Pad2_ eSim_NPN
Q30  Net-_Q26-Pad2_ Net-_Q30-Pad2_ Net-_D13-Pad2_ eSim_NPN
Q25  Net-_D11-Pad1_ Net-_Q25-Pad2_ Net-_Q23-Pad2_ eSim_NPN
Q26  Net-_D11-Pad1_ Net-_Q26-Pad2_ Net-_Q23-Pad2_ eSim_NPN
D11  Net-_D11-Pad1_ Net-_D11-Pad2_ eSim_Diode
R27  Net-_R1-Pad1_ Net-_Q29-Pad2_ 4k
R25  Net-_R1-Pad1_ Net-_Q30-Pad2_ 2k
R22  Net-_R1-Pad1_ Net-_D11-Pad1_ 2.5k
Q23  Net-_D11-Pad2_ Net-_Q23-Pad2_ GNDPWR eSim_NPN
Q21  Net-_Q17-Pad2_ Net-_D11-Pad2_ Net-_Q18-Pad2_ eSim_NPN
Q17  Net-_Q17-Pad1_ Net-_Q17-Pad2_ Net-_D9-Pad1_ eSim_NPN
R17  Net-_R1-Pad1_ Net-_Q17-Pad2_ 1.6k
R15  Net-_R1-Pad1_ Net-_Q17-Pad1_ 130
D13  GNDPWR Net-_D13-Pad2_ eSim_Diode
D15  GNDPWR Net-_D15-Pad2_ eSim_Diode
R21  Net-_Q23-Pad2_ GNDPWR 1k
R18  Net-_Q18-Pad2_ GNDPWR 1k
D9  Net-_D9-Pad1_ Net-_D9-Pad2_ eSim_Diode
Q18  Net-_D9-Pad2_ Net-_Q18-Pad2_ GNDPWR eSim_NPN
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_D1-Pad2_ eSim_NPN
Q2  Net-_Q2-Pad1_ Net-_Q2-Pad2_ Net-_D3-Pad2_ eSim_NPN
Q5  Net-_D5-Pad1_ Net-_Q1-Pad1_ Net-_Q5-Pad3_ eSim_NPN
Q6  Net-_D5-Pad1_ Net-_Q2-Pad1_ Net-_Q5-Pad3_ eSim_NPN
D5  Net-_D5-Pad1_ Net-_D5-Pad2_ eSim_Diode
R1  Net-_R1-Pad1_ Net-_Q1-Pad2_ 4k
R3  Net-_R1-Pad1_ Net-_Q2-Pad2_ 2k
R5  Net-_R1-Pad1_ Net-_D5-Pad1_ 2.5k
Q9  Net-_D5-Pad2_ Net-_Q5-Pad3_ GNDPWR eSim_NPN
Q11  Net-_Q11-Pad1_ Net-_D5-Pad2_ Net-_Q11-Pad3_ eSim_NPN
Q13  Net-_Q13-Pad1_ Net-_Q11-Pad1_ Net-_D7-Pad1_ eSim_NPN
R9  Net-_R1-Pad1_ Net-_Q11-Pad1_ 1.6k
R13  Net-_R1-Pad1_ Net-_Q13-Pad1_ 130
D3  GNDPWR Net-_D3-Pad2_ eSim_Diode
D1  GNDPWR Net-_D1-Pad2_ eSim_Diode
R6  Net-_Q5-Pad3_ GNDPWR 1k
R10  Net-_Q11-Pad3_ GNDPWR 1k
D7  Net-_D7-Pad1_ Net-_D7-Pad2_ eSim_Diode
Q14  Net-_D7-Pad2_ Net-_Q11-Pad3_ GNDPWR eSim_NPN
Q31  Net-_Q27-Pad2_ Net-_Q31-Pad2_ Net-_D16-Pad2_ eSim_NPN
Q32  Net-_Q28-Pad2_ Net-_Q32-Pad2_ Net-_D14-Pad2_ eSim_NPN
Q27  Net-_D12-Pad1_ Net-_Q27-Pad2_ Net-_Q24-Pad2_ eSim_NPN
Q28  Net-_D12-Pad1_ Net-_Q28-Pad2_ Net-_Q24-Pad2_ eSim_NPN
D12  Net-_D12-Pad1_ Net-_D12-Pad2_ eSim_Diode
R28  Net-_R1-Pad1_ Net-_Q31-Pad2_ 4k
R26  Net-_R1-Pad1_ Net-_Q32-Pad2_ 2k
R24  Net-_R1-Pad1_ Net-_D12-Pad1_ 2.5k
Q24  Net-_D12-Pad2_ Net-_Q24-Pad2_ GNDPWR eSim_NPN
Q22  Net-_Q19-Pad2_ Net-_D12-Pad2_ Net-_Q20-Pad2_ eSim_NPN
Q19  Net-_Q19-Pad1_ Net-_Q19-Pad2_ Net-_D10-Pad1_ eSim_NPN
R19  Net-_R1-Pad1_ Net-_Q19-Pad2_ 1.6k
R16  Net-_R1-Pad1_ Net-_Q19-Pad1_ 130
D14  GNDPWR Net-_D14-Pad2_ eSim_Diode
D16  GNDPWR Net-_D16-Pad2_ eSim_Diode
R23  Net-_Q24-Pad2_ GNDPWR 1k
R20  Net-_Q20-Pad2_ GNDPWR 1k
D10  Net-_D10-Pad1_ Net-_D10-Pad2_ eSim_Diode
Q20  Net-_D10-Pad2_ Net-_Q20-Pad2_ GNDPWR eSim_NPN
U1  Net-_D1-Pad2_ Net-_D3-Pad2_ Net-_D2-Pad2_ Net-_D4-Pad2_ Net-_D7-Pad2_ Net-_D8-Pad2_ Net-_R1-Pad1_ GNDPWR Net-_D9-Pad2_ Net-_D10-Pad2_ Net-_D15-Pad2_ Net-_D13-Pad2_ Net-_D16-Pad2_ Net-_D14-Pad2_ PORT

.end
