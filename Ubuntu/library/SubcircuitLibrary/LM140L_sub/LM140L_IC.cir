* D:\FOSSEE\eSim\library\SubcircuitLibrary\LM140L_IC\LM140L_IC.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 07/01/24 22:06:45

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
R1  Net-_J1-Pad1_ Net-_Q2-Pad3_ 418
J1  Net-_J1-Pad1_ Net-_J1-Pad2_ Net-_J1-Pad3_ jfet_n
U1  Net-_J1-Pad2_ Net-_J1-Pad3_ zener
Q1  Net-_Q1-Pad1_ Net-_J1-Pad3_ Net-_Q1-Pad3_ eSim_NPN
Q2  Net-_Q1-Pad3_ Net-_Q1-Pad1_ Net-_Q2-Pad3_ eSim_PNP
U2  Net-_J1-Pad2_ Net-_Q1-Pad3_ zener
Q3  Net-_Q1-Pad1_ Net-_Q1-Pad1_ Net-_J1-Pad1_ eSim_PNP
Q7  Net-_Q11-Pad3_ Net-_Q1-Pad1_ Net-_J1-Pad1_ eSim_PNP
Q4  Net-_Q1-Pad1_ Net-_Q1-Pad3_ Net-_Q4-Pad3_ eSim_NPN
R2  Net-_Q4-Pad3_ Net-_Q8-Pad2_ 576
R3  Net-_Q8-Pad2_ Net-_R3-Pad2_ 3.41k
R4  Net-_R3-Pad2_ Net-_Q10-Pad2_ 3.89k
Q5  Net-_Q10-Pad2_ Net-_Q10-Pad2_ Net-_Q5-Pad3_ eSim_NPN
Q6  Net-_Q5-Pad3_ Net-_Q5-Pad3_ Net-_J1-Pad2_ eSim_NPN
U3  Net-_R10-Pad1_ Net-_J1-Pad1_ zener
R10  Net-_R10-Pad1_ Net-_R10-Pad2_ 5k
U4  Net-_Q13-Pad2_ Net-_R10-Pad2_ zener
Q15  Net-_J1-Pad1_ Net-_Q11-Pad3_ Net-_Q12-Pad1_ eSim_NPN
Q9  Net-_Q11-Pad3_ Net-_Q8-Pad1_ Net-_J1-Pad2_ eSim_NPN
Q8  Net-_Q8-Pad1_ Net-_Q8-Pad2_ Net-_Q4-Pad3_ eSim_PNP
R5  Net-_Q8-Pad1_ Net-_J1-Pad2_ 7.8k
Q16  Net-_J1-Pad1_ Net-_Q12-Pad1_ Net-_Q16-Pad3_ eSim_NPN
Q12  Net-_Q12-Pad1_ Net-_Q12-Pad2_ Net-_Q10-Pad1_ eSim_NPN
R6  Net-_Q12-Pad2_ Net-_R3-Pad2_ 13k
Q11  Net-_J1-Pad2_ Net-_C1-Pad1_ Net-_Q11-Pad3_ eSim_PNP
R8  Net-_Q11-Pad3_ Net-_C1-Pad1_ 5.76k
Q14  Net-_C1-Pad1_ Net-_C1-Pad2_ Net-_Q10-Pad1_ eSim_NPN
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
R7  Net-_Q10-Pad3_ Net-_J1-Pad2_ 2.84k
R9  Net-_Q13-Pad3_ Net-_R13-Pad2_ 100
R14  Net-_Q16-Pad3_ Net-_R13-Pad2_ 1.9
R13  Net-_Q12-Pad1_ Net-_R13-Pad2_ 2.5k
R11  Net-_Q16-Pad3_ Net-_Q13-Pad2_ 100
R15  Net-_R13-Pad2_ Net-_R12-Pad1_ 1.5k
R12  Net-_R12-Pad1_ Net-_C1-Pad2_ 15k
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 5u
R16  Net-_R12-Pad1_ Net-_J1-Pad2_ 2.23k
Q13  Net-_Q11-Pad3_ Net-_Q13-Pad2_ Net-_Q13-Pad3_ eSim_NPN
U5  Net-_J1-Pad1_ Net-_R13-Pad2_ Net-_J1-Pad2_ PORT

.end
