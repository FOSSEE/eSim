* D:\FOSSEE\eSim\library\SubcircuitLibrary\SN5442A_IC\SN5442A_IC.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/30/24 18:49:44

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U11  Net-_U11-Pad1_ Net-_U11-Pad2_ Net-_U11-Pad3_ d_nand
U12  Net-_U10-Pad1_ Net-_U12-Pad2_ Net-_U12-Pad3_ d_nand
U31  Net-_U11-Pad3_ Net-_U11-Pad3_ Net-_U31-Pad3_ d_nand
U32  Net-_U12-Pad3_ Net-_U12-Pad3_ Net-_U32-Pad3_ d_nand
U51  Net-_U31-Pad3_ Net-_U32-Pad3_ Net-_U51-Pad3_ d_nand
U13  Net-_U13-Pad1_ Net-_U11-Pad2_ Net-_U13-Pad3_ d_nand
U14  Net-_U10-Pad1_ Net-_U12-Pad2_ Net-_U14-Pad3_ d_nand
U33  Net-_U13-Pad3_ Net-_U13-Pad3_ Net-_U33-Pad3_ d_nand
U34  Net-_U14-Pad3_ Net-_U14-Pad3_ Net-_U34-Pad3_ d_nand
U52  Net-_U33-Pad3_ Net-_U34-Pad3_ Net-_U52-Pad3_ d_nand
U15  Net-_U11-Pad1_ Net-_U15-Pad2_ Net-_U15-Pad3_ d_nand
U16  Net-_U10-Pad1_ Net-_U12-Pad2_ Net-_U16-Pad3_ d_nand
U35  Net-_U15-Pad3_ Net-_U15-Pad3_ Net-_U35-Pad3_ d_nand
U36  Net-_U16-Pad3_ Net-_U16-Pad3_ Net-_U36-Pad3_ d_nand
U53  Net-_U35-Pad3_ Net-_U36-Pad3_ Net-_U53-Pad3_ d_nand
U17  Net-_U13-Pad1_ Net-_U15-Pad2_ Net-_U17-Pad3_ d_nand
U18  Net-_U10-Pad1_ Net-_U12-Pad2_ Net-_U18-Pad3_ d_nand
U37  Net-_U17-Pad3_ Net-_U17-Pad3_ Net-_U37-Pad3_ d_nand
U38  Net-_U18-Pad3_ Net-_U18-Pad3_ Net-_U38-Pad3_ d_nand
U54  Net-_U37-Pad3_ Net-_U38-Pad3_ Net-_U54-Pad3_ d_nand
U19  Net-_U11-Pad1_ Net-_U11-Pad2_ Net-_U19-Pad3_ d_nand
U20  Net-_U10-Pad2_ Net-_U12-Pad2_ Net-_U20-Pad3_ d_nand
U39  Net-_U19-Pad3_ Net-_U19-Pad3_ Net-_U39-Pad3_ d_nand
U40  Net-_U20-Pad3_ Net-_U20-Pad3_ Net-_U40-Pad3_ d_nand
U55  Net-_U39-Pad3_ Net-_U40-Pad3_ Net-_U55-Pad3_ d_nand
U21  Net-_U13-Pad1_ Net-_U11-Pad2_ Net-_U21-Pad3_ d_nand
U22  Net-_U10-Pad2_ Net-_U12-Pad2_ Net-_U22-Pad3_ d_nand
U41  Net-_U21-Pad3_ Net-_U21-Pad3_ Net-_U41-Pad3_ d_nand
U42  Net-_U22-Pad3_ Net-_U22-Pad3_ Net-_U42-Pad3_ d_nand
U56  Net-_U41-Pad3_ Net-_U42-Pad3_ Net-_U56-Pad3_ d_nand
U23  Net-_U11-Pad1_ Net-_U15-Pad2_ Net-_U23-Pad3_ d_nand
U24  Net-_U10-Pad2_ Net-_U12-Pad2_ Net-_U24-Pad3_ d_nand
U43  Net-_U23-Pad3_ Net-_U23-Pad3_ Net-_U43-Pad3_ d_nand
U44  Net-_U24-Pad3_ Net-_U24-Pad3_ Net-_U44-Pad3_ d_nand
U57  Net-_U43-Pad3_ Net-_U44-Pad3_ Net-_U57-Pad3_ d_nand
U25  Net-_U13-Pad1_ Net-_U15-Pad2_ Net-_U25-Pad3_ d_nand
U26  Net-_U10-Pad2_ Net-_U12-Pad2_ Net-_U26-Pad3_ d_nand
U45  Net-_U25-Pad3_ Net-_U25-Pad3_ Net-_U45-Pad3_ d_nand
U46  Net-_U26-Pad3_ Net-_U26-Pad3_ Net-_U46-Pad3_ d_nand
U58  Net-_U45-Pad3_ Net-_U46-Pad3_ Net-_U58-Pad3_ d_nand
U27  Net-_U11-Pad1_ Net-_U11-Pad2_ Net-_U27-Pad3_ d_nand
U28  Net-_U10-Pad1_ Net-_U28-Pad2_ Net-_U28-Pad3_ d_nand
U47  Net-_U27-Pad3_ Net-_U27-Pad3_ Net-_U47-Pad3_ d_nand
U48  Net-_U28-Pad3_ Net-_U28-Pad3_ Net-_U48-Pad3_ d_nand
U59  Net-_U47-Pad3_ Net-_U48-Pad3_ Net-_U59-Pad3_ d_nand
U29  Net-_U13-Pad1_ Net-_U11-Pad2_ Net-_U29-Pad3_ d_nand
U30  Net-_U10-Pad1_ Net-_U28-Pad2_ Net-_U30-Pad3_ d_nand
U49  Net-_U29-Pad3_ Net-_U29-Pad3_ Net-_U49-Pad3_ d_nand
U50  Net-_U30-Pad3_ Net-_U30-Pad3_ Net-_U50-Pad3_ d_nand
U60  Net-_U49-Pad3_ Net-_U50-Pad3_ Net-_U60-Pad3_ d_nand
U4  Net-_U2-Pad5_ Net-_U11-Pad1_ d_inverter
U9  Net-_U11-Pad1_ Net-_U13-Pad1_ d_inverter
U3  Net-_U2-Pad6_ Net-_U11-Pad2_ d_inverter
U7  Net-_U11-Pad2_ Net-_U15-Pad2_ d_inverter
U6  Net-_U2-Pad7_ Net-_U10-Pad1_ d_inverter
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ d_inverter
U5  Net-_U2-Pad8_ Net-_U12-Pad2_ d_inverter
U8  Net-_U12-Pad2_ Net-_U28-Pad2_ d_inverter
U62  Net-_U51-Pad3_ Net-_U52-Pad3_ Net-_U53-Pad3_ Net-_U54-Pad3_ Net-_U55-Pad3_ Net-_U56-Pad3_ Net-_U57-Pad3_ Net-_U58-Pad3_ Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ dac_bridge_8
U61  Net-_U59-Pad3_ Net-_U60-Pad3_ Net-_U1-Pad9_ Net-_U1-Pad10_ dac_bridge_2
U2  Net-_U1-Pad14_ Net-_U1-Pad13_ Net-_U1-Pad12_ Net-_U1-Pad11_ Net-_U2-Pad5_ Net-_U2-Pad6_ Net-_U2-Pad7_ Net-_U2-Pad8_ adc_bridge_4
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ PORT

.end
