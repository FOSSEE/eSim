* C:\FOSSEE\eSim\library\SubcircuitLibrary\IC_OPA827\IC_OPA827.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 03/14/23 18:08:37

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
Q1  Net-_C1-Pad1_ Net-_Q1-Pad2_ Net-_J1-Pad3_ eSim_PNP
Q3  Net-_Q1-Pad2_ Net-_Q1-Pad2_ Net-_J2-Pad3_ eSim_PNP
Q4  Net-_Q1-Pad2_ Net-_Q1-Pad2_ Net-_J3-Pad1_ eSim_PNP
Q5  Net-_C2-Pad2_ Net-_Q1-Pad2_ Net-_J4-Pad1_ eSim_PNP
Q8  Net-_Q7-Pad1_ Net-_Q7-Pad1_ Net-_J1-Pad1_ eSim_PNP
Q9  Net-_C2-Pad1_ Net-_Q7-Pad1_ Net-_J1-Pad1_ eSim_PNP
Q2  Net-_C1-Pad1_ Net-_Q10-Pad3_ Net-_Q2-Pad3_ eSim_NPN
Q6  Net-_C2-Pad2_ Net-_Q10-Pad3_ Net-_Q6-Pad3_ eSim_NPN
Q7  Net-_Q7-Pad1_ Net-_C1-Pad1_ Net-_Q10-Pad3_ eSim_NPN
Q10  Net-_C2-Pad1_ Net-_C2-Pad2_ Net-_Q10-Pad3_ eSim_NPN
Q11  Net-_J1-Pad1_ Net-_C2-Pad1_ Net-_Q11-Pad3_ eSim_NPN
Q12  Net-_C1-Pad1_ Net-_C2-Pad1_ Net-_Q12-Pad3_ eSim_PNP
Q13  Net-_J1-Pad1_ Net-_Q12-Pad3_ Net-_Q13-Pad3_ eSim_NPN
Q14  Net-_C1-Pad1_ Net-_Q11-Pad3_ Net-_Q13-Pad3_ eSim_PNP
C1  Net-_C1-Pad1_ Net-_C1-Pad1_ 0.1u
C2  Net-_C2-Pad1_ Net-_C2-Pad2_ 0.1u
R1  Net-_Q2-Pad3_ Net-_C1-Pad1_ 200
R2  Net-_Q6-Pad3_ Net-_C1-Pad1_ 200
U1  Net-_J1-Pad2_ Net-_J1-Pad1_ Net-_J3-Pad2_ Net-_C1-Pad1_ Net-_Q13-Pad3_ PORT
J1  Net-_J1-Pad1_ Net-_J1-Pad2_ Net-_J1-Pad3_ jfet_n
J2  Net-_J1-Pad1_ Net-_J1-Pad2_ Net-_J2-Pad3_ jfet_n
J3  Net-_J3-Pad1_ Net-_J3-Pad2_ Net-_J1-Pad1_ jfet_n
J4  Net-_J4-Pad1_ Net-_J3-Pad2_ Net-_J1-Pad1_ jfet_n
R3  Net-_Q1-Pad2_ Net-_C1-Pad1_ 5k
R4  Net-_Q10-Pad3_ Net-_C1-Pad1_ 5k
R5  Net-_Q11-Pad3_ Net-_C1-Pad1_ 500
R6  Net-_J1-Pad1_ Net-_Q12-Pad3_ 10

.end
