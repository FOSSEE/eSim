* C:\FOSSEE2\eSim\library\SubcircuitLibrary\LM301-PORT\LM301-PORT.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/14/24 12:28:46

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
Q3  Net-_J1-Pad1_ Net-_Q1-Pad3_ Net-_Q1-Pad2_ eSim_NPN
Q1  Net-_J1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
Q5  Net-_Q2-Pad1_ Net-_Q11-Pad2_ Net-_Q1-Pad2_ eSim_PNP
Q12  Net-_J1-Pad1_ Net-_Q12-Pad2_ Net-_Q11-Pad3_ eSim_NPN
Q13  Net-_J1-Pad1_ Net-_Q11-Pad3_ Net-_Q12-Pad2_ eSim_NPN
Q11  Net-_J1-Pad1_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_PNP
Q4  Net-_J1-Pad1_ Net-_Q2-Pad1_ Net-_Q10-Pad2_ eSim_NPN
Q2  Net-_Q2-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad1_ eSim_NPN
R1  Net-_Q10-Pad2_ Net-_Q10-Pad1_ 40k
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_J1-Pad1_ eSim_PNP
Q8  Net-_J1-Pad1_ Net-_Q14-Pad1_ Net-_Q7-Pad2_ eSim_NPN
Q7  Net-_Q11-Pad2_ Net-_Q7-Pad2_ Net-_Q7-Pad3_ eSim_NPN
R3  Net-_Q7-Pad2_ Net-_R2-Pad2_ 20k
R4  Net-_R2-Pad2_ Net-_J1-Pad2_ 20k
J1  Net-_J1-Pad1_ Net-_J1-Pad2_ Net-_J1-Pad3_ jfet_n
R5  Net-_J1-Pad3_ Net-_Q14-Pad1_ 450
Q14  Net-_Q14-Pad1_ Net-_Q14-Pad2_ Net-_J1-Pad2_ eSim_NPN
R6  Net-_Q14-Pad2_ Net-_J1-Pad2_ 10k
Q15  Net-_J1-Pad1_ Net-_J1-Pad3_ Net-_Q14-Pad2_ eSim_NPN
Q16  Net-_Q16-Pad1_ Net-_Q10-Pad1_ Net-_J1-Pad2_ eSim_NPN
R7  Net-_J1-Pad1_ Net-_Q16-Pad1_ 120
Q17  Net-_J1-Pad1_ Net-_Q16-Pad1_ Net-_Q17-Pad3_ eSim_NPN
Q19  Net-_Q19-Pad1_ Net-_Q17-Pad3_ Net-_Q10-Pad1_ eSim_NPN
R8  Net-_Q17-Pad3_ Net-_Q10-Pad1_ 40k
R9  Net-_J1-Pad1_ Net-_Q19-Pad1_ 1k
Q22  Net-_J1-Pad2_ Net-_Q19-Pad1_ Net-_Q21-Pad3_ eSim_PNP
Q25  Net-_Q25-Pad1_ Net-_Q19-Pad1_ Net-_Q25-Pad3_ eSim_PNP
R13  Net-_J1-Pad1_ Net-_Q25-Pad3_ 7.5k
R14  Net-_Q23-Pad2_ Net-_Q25-Pad3_ 65
R11  Net-_Q25-Pad1_ Net-_Q10-Pad1_ 80k
Q26  Net-_Q25-Pad3_ ? Net-_J1-Pad2_ eSim_NPN
Q6  Net-_Q11-Pad2_ Net-_Q11-Pad2_ Net-_Q1-Pad2_ eSim_PNP
Q9  Net-_Q11-Pad2_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_PNP
Q18  Net-_J1-Pad1_ Net-_J1-Pad1_ Net-_J1-Pad1_ eSim_PNP
Q20  Net-_Q20-Pad1_ Net-_J1-Pad1_ Net-_J1-Pad1_ eSim_PNP
Q21  Net-_Q20-Pad1_ Net-_Q20-Pad1_ Net-_Q21-Pad3_ eSim_NPN
Q23  Net-_Q20-Pad1_ Net-_Q23-Pad2_ Net-_Q23-Pad3_ eSim_NPN
Q24  Net-_J1-Pad1_ Net-_Q20-Pad1_ Net-_Q23-Pad2_ eSim_NPN
R10  Net-_Q23-Pad2_ Net-_Q23-Pad3_ 25
R12  Net-_Q10-Pad1_ Net-_J1-Pad2_ 650
R2  Net-_Q7-Pad3_ Net-_R2-Pad2_ 5k
U1  Net-_J1-Pad1_ Net-_Q12-Pad2_ Net-_Q1-Pad3_ Net-_J1-Pad2_ Net-_Q2-Pad1_ Net-_Q23-Pad3_ Net-_J1-Pad1_ Net-_J1-Pad1_ PORT

.end
