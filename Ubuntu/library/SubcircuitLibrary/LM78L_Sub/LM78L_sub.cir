* C:\FOSSEE\eSim\library\SubcircuitLibrary\LM78L_sub\LM78L_sub.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/19/24 13:33:00

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
R1  Net-_J1-Pad1_ Net-_Q2-Pad3_ 418
J1  Net-_J1-Pad1_ Net-_J1-Pad2_ Net-_J1-Pad3_ jfet_n
Q2  Net-_Q1-Pad3_ Net-_Q1-Pad1_ Net-_Q2-Pad3_ eSim_PNP
Q3  Net-_Q1-Pad1_ Net-_Q1-Pad1_ Net-_J1-Pad1_ eSim_PNP
Q8  Net-_Q12-Pad3_ Net-_Q1-Pad1_ Net-_J1-Pad1_ eSim_PNP
Q1  Net-_Q1-Pad1_ Net-_J1-Pad3_ Net-_Q1-Pad3_ eSim_NPN
Q4  Net-_Q1-Pad1_ Net-_Q1-Pad3_ Net-_Q4-Pad3_ eSim_NPN
R2  Net-_Q4-Pad3_ Net-_Q7-Pad2_ 576
Q7  Net-_Q7-Pad1_ Net-_Q7-Pad2_ Net-_Q4-Pad3_ eSim_PNP
R3  Net-_Q7-Pad2_ Net-_R3-Pad2_ 3.41k
U1  ? Net-_J1-Pad3_ zener
R4  Net-_R3-Pad2_ Net-_Q11-Pad2_ 3.89k
Q5  Net-_Q11-Pad2_ Net-_Q11-Pad2_ Net-_Q5-Pad3_ eSim_NPN
Q6  Net-_Q5-Pad3_ Net-_Q5-Pad3_ Net-_J1-Pad2_ eSim_NPN
U2  Net-_J1-Pad2_ Net-_Q1-Pad3_ zener
R5  Net-_Q7-Pad1_ Net-_J1-Pad2_ 7.8k
Q9  Net-_Q12-Pad3_ Net-_Q7-Pad1_ Net-_J1-Pad2_ eSim_NPN
Q12  Net-_J1-Pad2_ Net-_C1-Pad1_ Net-_Q12-Pad3_ eSim_PNP
R8  Net-_Q12-Pad3_ Net-_C1-Pad1_ 5.76k
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
Q13  Net-_C1-Pad1_ Net-_C1-Pad2_ Net-_Q10-Pad3_ eSim_NPN
R6  Net-_Q10-Pad2_ Net-_R3-Pad2_ 13k
Q14  Net-_Q12-Pad3_ Net-_Q14-Pad2_ Net-_Q14-Pad3_ eSim_NPN
R9  Net-_Q14-Pad3_ Net-_R13-Pad1_ 100
U4  Net-_Q14-Pad2_ Net-_R10-Pad1_ zener
R11  Net-_Q16-Pad3_ Net-_Q14-Pad2_ 100
Q15  Net-_J1-Pad1_ Net-_Q12-Pad3_ Net-_Q10-Pad1_ eSim_NPN
R13  Net-_R13-Pad1_ Net-_Q10-Pad1_ 2.5k
Q16  Net-_J1-Pad1_ Net-_Q10-Pad1_ Net-_Q16-Pad3_ eSim_NPN
R14  Net-_R13-Pad1_ Net-_Q16-Pad3_ 1.9
R10  Net-_R10-Pad1_ Net-_R10-Pad2_ 5k
U3  Net-_R10-Pad2_ Net-_J1-Pad1_ zener
Q11  Net-_Q10-Pad3_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_NPN
R7  Net-_Q11-Pad3_ Net-_J1-Pad2_ 2.84k
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 5pF
R12  Net-_R12-Pad1_ Net-_C1-Pad2_ 15k
R15  Net-_R12-Pad1_ Net-_R13-Pad1_ 1.5k
R16  Net-_J1-Pad2_ Net-_R12-Pad1_ 2.23k
U5  Net-_J1-Pad1_ Net-_R13-Pad1_ Net-_J1-Pad2_ PORT

.end
