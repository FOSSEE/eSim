* C:\FOSSEE_mains\FOSSEE\eSim\library\SubcircuitLibrary\SN54LS183\SN54LS183.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 01/10/25 22:53:19

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U2  Net-_U2-Pad1_ Net-_U2-Pad2_ Net-_U2-Pad3_ d_and
U3  Net-_U2-Pad2_ Net-_U18-Pad2_ Net-_U20-Pad2_ d_and
U4  Net-_U2-Pad1_ Net-_U18-Pad2_ Net-_U28-Pad2_ d_and
U5  Net-_U1-Pad4_ Net-_U2-Pad2_ Net-_U16-Pad1_ d_and
U16  Net-_U16-Pad1_ Net-_U1-Pad1_ Net-_U16-Pad3_ d_and
U6  Net-_U2-Pad1_ Net-_U1-Pad3_ Net-_U17-Pad1_ d_and
U17  Net-_U17-Pad1_ Net-_U1-Pad1_ Net-_U17-Pad3_ d_and
U7  Net-_U2-Pad1_ Net-_U2-Pad2_ Net-_U18-Pad1_ d_and
U18  Net-_U18-Pad1_ Net-_U18-Pad2_ Net-_U18-Pad3_ d_and
U8  Net-_U1-Pad4_ Net-_U1-Pad3_ Net-_U19-Pad1_ d_and
U19  Net-_U19-Pad1_ Net-_U18-Pad2_ Net-_U19-Pad3_ d_and
U9  Net-_U11-Pad1_ Net-_U10-Pad1_ Net-_U25-Pad1_ d_and
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ Net-_U10-Pad3_ d_and
U11  Net-_U11-Pad1_ Net-_U10-Pad2_ Net-_U11-Pad3_ d_and
U12  Net-_U1-Pad11_ Net-_U10-Pad1_ Net-_U12-Pad3_ d_and
U21  Net-_U12-Pad3_ Net-_U1-Pad13_ Net-_U21-Pad3_ d_and
U13  Net-_U11-Pad1_ Net-_U1-Pad12_ Net-_U13-Pad3_ d_and
U22  Net-_U13-Pad3_ Net-_U1-Pad13_ Net-_U22-Pad3_ d_and
U25  Net-_U25-Pad1_ Net-_U10-Pad3_ Net-_U25-Pad3_ d_nor
U31  Net-_U25-Pad3_ Net-_U11-Pad3_ Net-_U1-Pad10_ d_nor
U29  Net-_U21-Pad3_ Net-_U22-Pad3_ Net-_U29-Pad3_ d_nor
U30  Net-_U23-Pad3_ Net-_U24-Pad3_ Net-_U30-Pad3_ d_nor
U33  Net-_U29-Pad3_ Net-_U30-Pad3_ Net-_U1-Pad8_ d_nor
U14  Net-_U11-Pad1_ Net-_U10-Pad1_ Net-_U14-Pad3_ d_and
U23  Net-_U14-Pad3_ Net-_U10-Pad2_ Net-_U23-Pad3_ d_and
U15  Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U15-Pad3_ d_and
U24  Net-_U15-Pad3_ Net-_U10-Pad2_ Net-_U24-Pad3_ d_and
U1  Net-_U1-Pad1_ ? Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ ? Net-_U1-Pad8_ ? Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ ? PORT
U35  Net-_U1-Pad4_ Net-_U2-Pad1_ d_inverter
U34  Net-_U1-Pad3_ Net-_U2-Pad2_ d_inverter
U36  Net-_U1-Pad1_ Net-_U18-Pad2_ d_inverter
U38  Net-_U1-Pad11_ Net-_U11-Pad1_ d_inverter
U37  Net-_U1-Pad12_ Net-_U10-Pad1_ d_inverter
U39  Net-_U1-Pad13_ Net-_U10-Pad2_ d_inverter
U20  Net-_U2-Pad3_ Net-_U20-Pad2_ Net-_U20-Pad3_ d_or
U28  Net-_U20-Pad3_ Net-_U28-Pad2_ Net-_U28-Pad3_ d_or
U40  Net-_U28-Pad3_ Net-_U1-Pad5_ d_inverter
U41  Net-_U32-Pad3_ Net-_U1-Pad6_ d_inverter
U26  Net-_U16-Pad3_ Net-_U17-Pad3_ Net-_U26-Pad3_ d_or
U27  Net-_U18-Pad3_ Net-_U19-Pad3_ Net-_U27-Pad3_ d_or
U32  Net-_U26-Pad3_ Net-_U27-Pad3_ Net-_U32-Pad3_ d_or

.end
