* C:\FOSSEE\eSim\library\SubcircuitLibrary\AS321_Sub\AS321_Sub.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 07/14/24 17:22:58

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
I1  Net-_I1-Pad1_ Net-_I1-Pad2_ 6uA
I2  Net-_I1-Pad1_ Net-_I2-Pad2_ 4uA
I4  Net-_I1-Pad1_ Net-_C1-Pad1_ 100uA
Q2  Net-_Q2-Pad1_ Net-_Q1-Pad3_ Net-_I1-Pad2_ eSim_PNP
Q1  Net-_I3-Pad2_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_PNP
Q5  Net-_C1-Pad2_ Net-_Q5-Pad2_ Net-_I1-Pad2_ eSim_PNP
Q6  Net-_I3-Pad2_ Net-_Q6-Pad2_ Net-_Q5-Pad2_ eSim_PNP
Q3  Net-_Q2-Pad1_ Net-_Q2-Pad1_ Net-_I3-Pad2_ eSim_NPN
Q4  Net-_C1-Pad2_ Net-_Q2-Pad1_ Net-_I3-Pad2_ eSim_NPN
Q7  Net-_I3-Pad2_ Net-_C1-Pad2_ Net-_I2-Pad2_ eSim_PNP
Q8  Net-_I1-Pad1_ Net-_I2-Pad2_ Net-_I3-Pad1_ eSim_NPN
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 20pF
I3  Net-_I3-Pad1_ Net-_I3-Pad2_ 50uA
Q9  Net-_C1-Pad1_ Net-_I3-Pad1_ Net-_I3-Pad2_ eSim_NPN
Q10  Net-_C1-Pad1_ Net-_Q10-Pad2_ Net-_I5-Pad1_ eSim_NPN
I5  Net-_I5-Pad1_ Net-_I3-Pad2_ 50uA
Q13  Net-_I3-Pad2_ Net-_C1-Pad1_ Net-_I5-Pad1_ eSim_PNP
R3  Net-_Q10-Pad2_ Net-_I5-Pad1_ 500
Q11  Net-_I1-Pad1_ Net-_C1-Pad1_ Net-_Q11-Pad3_ eSim_NPN
Q12  Net-_I1-Pad1_ Net-_Q11-Pad3_ Net-_Q10-Pad2_ eSim_NPN
R2  Net-_Q1-Pad2_ Net-_I5-Pad1_ 8k
R1  Net-_R1-Pad1_ Net-_Q1-Pad2_ 2k
U1  Net-_Q6-Pad2_ Net-_I3-Pad2_ Net-_R1-Pad1_ Net-_I5-Pad1_ Net-_I1-Pad1_ PORT

.end
