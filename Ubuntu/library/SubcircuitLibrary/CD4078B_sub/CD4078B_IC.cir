* D:\FOSSEE\eSim\library\SubcircuitLibrary\CD4078B_IC\CD4078B_IC.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 06/18/24 16:43:14

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U3  Net-_U2-Pad9_ Net-_U11-Pad1_ d_inverter
U4  Net-_U2-Pad10_ Net-_U11-Pad2_ d_inverter
U5  Net-_U2-Pad11_ Net-_U12-Pad1_ d_inverter
U6  Net-_U2-Pad12_ Net-_U12-Pad2_ d_inverter
U7  Net-_U2-Pad13_ Net-_U13-Pad1_ d_inverter
U8  Net-_U2-Pad14_ Net-_U13-Pad2_ d_inverter
U9  Net-_U2-Pad15_ Net-_U14-Pad1_ d_inverter
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ d_inverter
U21  Net-_U19-Pad3_ Net-_U20-Pad3_ Net-_U21-Pad3_ d_nor
U22  Net-_U21-Pad3_ Net-_U22-Pad2_ d_inverter
U24  Net-_U22-Pad2_ Net-_U24-Pad2_ d_inverter
U23  Net-_U21-Pad3_ Net-_U23-Pad2_ d_inverter
U25  Net-_U24-Pad2_ Net-_U23-Pad2_ Net-_U1-Pad10_ Net-_U1-Pad9_ dac_bridge_2
U2  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U2-Pad9_ Net-_U2-Pad10_ Net-_U2-Pad11_ Net-_U2-Pad12_ Net-_U2-Pad13_ Net-_U2-Pad14_ Net-_U2-Pad15_ Net-_U10-Pad1_ adc_bridge_8
U11  Net-_U11-Pad1_ Net-_U11-Pad2_ Net-_U11-Pad3_ d_nand
U12  Net-_U12-Pad1_ Net-_U12-Pad2_ Net-_U12-Pad3_ d_nand
U15  Net-_U11-Pad3_ Net-_U11-Pad3_ Net-_U15-Pad3_ d_nand
U16  Net-_U12-Pad3_ Net-_U12-Pad3_ Net-_U16-Pad3_ d_nand
U19  Net-_U15-Pad3_ Net-_U16-Pad3_ Net-_U19-Pad3_ d_nand
U13  Net-_U13-Pad1_ Net-_U13-Pad2_ Net-_U13-Pad3_ d_nand
U14  Net-_U14-Pad1_ Net-_U10-Pad2_ Net-_U14-Pad3_ d_nand
U17  Net-_U13-Pad3_ Net-_U13-Pad3_ Net-_U17-Pad3_ d_nand
U18  Net-_U14-Pad3_ Net-_U14-Pad3_ Net-_U18-Pad3_ d_nand
U20  Net-_U17-Pad3_ Net-_U18-Pad3_ Net-_U20-Pad3_ d_nand
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ PORT

.end
