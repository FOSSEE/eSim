* C:\FOSSEE_mains\FOSSEE\eSim\library\SubcircuitLibrary\CD4532B\CD4532B.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 02/10/25 20:14:54

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U2  Net-_U1-Pad11_ Net-_U2-Pad2_ d_inverter
U3  Net-_U1-Pad12_ Net-_U10-Pad1_ d_inverter
U4  Net-_U1-Pad13_ Net-_U4-Pad2_ d_inverter
U5  Net-_U1-Pad1_ Net-_U11-Pad1_ d_inverter
U7  Net-_U1-Pad2_ Net-_U12-Pad1_ d_inverter
U8  Net-_U1-Pad3_ Net-_U13-Pad1_ d_inverter
U6  Net-_U1-Pad4_ Net-_U6-Pad2_ d_inverter
U9  Net-_U1-Pad5_ Net-_U14-Pad1_ d_inverter
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ d_inverter
U11  Net-_U11-Pad1_ Net-_U11-Pad2_ d_inverter
U12  Net-_U12-Pad1_ Net-_U12-Pad2_ d_inverter
U13  Net-_U13-Pad1_ Net-_U13-Pad2_ d_inverter
U14  Net-_U14-Pad1_ Net-_U14-Pad2_ d_inverter
X1  Net-_U2-Pad2_ Net-_U10-Pad2_ Net-_U11-Pad2_ Net-_U13-Pad2_ Net-_X1-Pad5_ 4_OR
X2  Net-_U13-Pad2_ Net-_U11-Pad2_ Net-_U4-Pad2_ ? Net-_X2-Pad5_ 4_OR
X3  Net-_U10-Pad1_ Net-_U11-Pad2_ Net-_U12-Pad2_ ? Net-_X3-Pad5_ 4_OR
X4  Net-_U4-Pad2_ Net-_U11-Pad2_ Net-_U12-Pad2_ ? Net-_X4-Pad5_ 4_OR
U22  Net-_U22-Pad1_ Net-_U16-Pad1_ d_inverter
U23  Net-_U23-Pad1_ Net-_U15-Pad1_ d_inverter
U24  Net-_U16-Pad1_ Net-_U15-Pad1_ Net-_U24-Pad3_ d_nand
X5  Net-_X1-Pad5_ Net-_X2-Pad5_ Net-_U19-Pad3_ Net-_U6-Pad2_ Net-_U25-Pad1_ 4_and
X6  Net-_X3-Pad5_ Net-_X4-Pad5_ Net-_U13-Pad1_ Net-_U6-Pad2_ Net-_U27-Pad1_ 4_and
X7  Net-_U11-Pad1_ Net-_U12-Pad1_ Net-_U13-Pad1_ Net-_U6-Pad2_ Net-_U26-Pad1_ 4_and
U25  Net-_U25-Pad1_ Net-_U25-Pad2_ d_inverter
U27  Net-_U27-Pad1_ Net-_U27-Pad2_ d_inverter
U26  Net-_U26-Pad1_ Net-_U26-Pad2_ d_inverter
U29  Net-_U25-Pad2_ Net-_U14-Pad2_ Net-_U29-Pad3_ d_nand
U30  Net-_U27-Pad2_ Net-_U14-Pad2_ Net-_U30-Pad3_ d_nand
U31  Net-_U26-Pad2_ Net-_U14-Pad2_ Net-_U31-Pad3_ d_nand
U32  Net-_U24-Pad3_ Net-_U1-Pad5_ Net-_U32-Pad3_ d_nand
U34  Net-_U29-Pad3_ Net-_U1-Pad9_ d_inverter
U33  Net-_U30-Pad3_ Net-_U1-Pad7_ d_inverter
U36  Net-_U31-Pad3_ Net-_U1-Pad6_ d_inverter
U37  Net-_U32-Pad3_ Net-_U1-Pad14_ d_inverter
U35  Net-_U20-Pad3_ Net-_U1-Pad15_ d_inverter
U19  Net-_U13-Pad2_ Net-_U12-Pad1_ Net-_U19-Pad3_ d_or
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ ? Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ ? PORT
X8  Net-_U1-Pad4_ Net-_U1-Pad3_ Net-_U1-Pad2_ Net-_U1-Pad1_ Net-_U22-Pad1_ 4_OR
X9  Net-_U1-Pad13_ Net-_U1-Pad12_ Net-_U1-Pad11_ Net-_U1-Pad10_ Net-_U23-Pad1_ 4_OR
U16  Net-_U16-Pad1_ Net-_U16-Pad2_ d_inverter
U17  Net-_U1-Pad5_ Net-_U17-Pad2_ d_inverter
U15  Net-_U15-Pad1_ Net-_U15-Pad2_ d_inverter
U18  Net-_U15-Pad2_ Net-_U16-Pad2_ Net-_U18-Pad3_ d_or
U20  Net-_U18-Pad3_ Net-_U17-Pad2_ Net-_U20-Pad3_ d_or

.end
