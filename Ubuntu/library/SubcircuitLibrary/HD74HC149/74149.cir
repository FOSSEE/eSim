* C:\FOSSEE\eSim\library\SubcircuitLibrary\74149\74149.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 05/12/25 14:03:04

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U2  Net-_U1-Pad9_ Net-_U14-Pad1_ d_inverter
U3  Net-_U1-Pad8_ Net-_U11-Pad1_ d_inverter
U4  Net-_U1-Pad7_ Net-_U12-Pad1_ d_inverter
U5  Net-_U1-Pad6_ Net-_U13-Pad1_ d_inverter
U6  Net-_U1-Pad5_ Net-_U15-Pad1_ d_inverter
U7  Net-_U1-Pad4_ Net-_U16-Pad1_ d_inverter
U8  Net-_U1-Pad3_ Net-_U19-Pad1_ d_inverter
U9  Net-_U1-Pad2_ Net-_U17-Pad1_ d_inverter
U10  Net-_U1-Pad1_ Net-_U10-Pad2_ d_inverter
U14  Net-_U14-Pad1_ Net-_U14-Pad2_ d_inverter
U11  Net-_U11-Pad1_ Net-_U11-Pad2_ d_inverter
U13  Net-_U13-Pad1_ Net-_U13-Pad2_ d_inverter
U15  Net-_U15-Pad1_ Net-_U15-Pad2_ d_inverter
U16  Net-_U16-Pad1_ Net-_U16-Pad2_ d_inverter
U19  Net-_U19-Pad1_ Net-_U19-Pad2_ d_inverter
U17  Net-_U17-Pad1_ Net-_U17-Pad2_ d_inverter
U18  Net-_U10-Pad2_ Net-_U18-Pad2_ d_inverter
U20  Net-_U18-Pad2_ Net-_U20-Pad2_ d_inverter
U21  Net-_U11-Pad1_ Net-_U14-Pad2_ Net-_U21-Pad3_ d_and
U24  Net-_U14-Pad1_ Net-_U20-Pad2_ Net-_U1-Pad18_ d_nand
U25  Net-_U21-Pad3_ Net-_U20-Pad2_ Net-_U1-Pad17_ d_nand
X1  Net-_U12-Pad1_ Net-_U14-Pad2_ Net-_U11-Pad2_ Net-_U26-Pad1_ 3_and
X2  Net-_U13-Pad1_ Net-_U14-Pad2_ Net-_U11-Pad2_ Net-_U12-Pad2_ Net-_U27-Pad1_ 4_and
X3  Net-_U14-Pad2_ Net-_U11-Pad2_ Net-_U12-Pad2_ Net-_U13-Pad2_ Net-_U23-Pad1_ 4_and
U26  Net-_U26-Pad1_ Net-_U20-Pad2_ Net-_U1-Pad16_ d_nand
U12  Net-_U12-Pad1_ Net-_U12-Pad2_ d_inverter
U27  Net-_U27-Pad1_ Net-_U20-Pad2_ Net-_U1-Pad15_ d_nand
X7  Net-_U15-Pad1_ Net-_U23-Pad1_ Net-_U20-Pad2_ Net-_U29-Pad1_ 3_and
U29  Net-_U29-Pad1_ Net-_U1-Pad14_ d_inverter
U22  Net-_U16-Pad1_ Net-_U15-Pad2_ Net-_U22-Pad3_ d_and
X4  Net-_U19-Pad1_ Net-_U15-Pad2_ Net-_U16-Pad2_ Net-_X4-Pad4_ 3_and
X5  Net-_U17-Pad1_ Net-_U15-Pad2_ Net-_U16-Pad2_ Net-_U19-Pad2_ Net-_X10-Pad1_ 4_and
X6  Net-_U15-Pad2_ Net-_U16-Pad2_ Net-_U19-Pad2_ Net-_U17-Pad2_ Net-_U23-Pad2_ 4_and
X8  Net-_U22-Pad3_ Net-_U23-Pad1_ Net-_U20-Pad2_ Net-_U30-Pad1_ 3_and
X9  Net-_X4-Pad4_ Net-_U23-Pad1_ Net-_U20-Pad2_ Net-_U31-Pad1_ 3_and
X10  Net-_X10-Pad1_ Net-_U23-Pad1_ Net-_U20-Pad2_ Net-_U32-Pad1_ 3_and
U28  Net-_U23-Pad3_ Net-_U20-Pad2_ Net-_U1-Pad10_ d_nand
U30  Net-_U30-Pad1_ Net-_U1-Pad13_ d_inverter
U31  Net-_U31-Pad1_ Net-_U1-Pad12_ d_inverter
U32  Net-_U32-Pad1_ Net-_U1-Pad11_ d_inverter
U23  Net-_U23-Pad1_ Net-_U23-Pad2_ Net-_U23-Pad3_ d_nand
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ Net-_U1-Pad16_ Net-_U1-Pad17_ Net-_U1-Pad18_ PORT

.end
