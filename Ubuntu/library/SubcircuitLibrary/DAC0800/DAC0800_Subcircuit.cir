* C:\FOSSEE\eSim\library\SubcircuitLibrary\DAC0800_Subcircuit\DAC0800_Subcircuit.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 12/28/24 13:16:39

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U1  Net-_Q1-Pad2_ Net-_Q3-Pad2_ Net-_Q4-Pad2_ Net-_D2-Pad1_ Net-_D3-Pad2_ Net-_D1-Pad2_ Net-_Q11-Pad2_ Net-_Q16-Pad2_ Net-_Q21-Pad2_ Net-_Q26-Pad2_ Net-_Q32-Pad2_ Net-_Q37-Pad2_ Net-_Q42-Pad2_ Net-_Q47-Pad2_ Net-_Q14-Pad1_ Net-_Q12-Pad1_ PORT
D2  Net-_D2-Pad1_ Net-_D2-Pad2_ eSim_Diode
D3  Net-_D2-Pad2_ Net-_D3-Pad2_ eSim_Diode
Q1  Net-_D1-Pad1_ Net-_Q1-Pad2_ Net-_D2-Pad1_ eSim_PNP
Q3  Net-_Q2-Pad1_ Net-_Q3-Pad2_ Net-_D2-Pad1_ eSim_PNP
Q2  Net-_Q2-Pad1_ Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_NPN
D1  Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
Q4  Net-_D2-Pad1_ Net-_Q4-Pad2_ Net-_D1-Pad2_ eSim_NPN
Q8  Net-_Q8-Pad1_ Net-_D2-Pad1_ Net-_D2-Pad1_ eSim_PNP
Q11  Net-_Q11-Pad1_ Net-_Q11-Pad2_ Net-_D2-Pad1_ eSim_PNP
Q13  Net-_Q13-Pad1_ Net-_D2-Pad1_ Net-_D2-Pad1_ eSim_PNP
Q16  Net-_Q16-Pad1_ Net-_Q16-Pad2_ Net-_D2-Pad1_ eSim_PNP
Q18  Net-_Q18-Pad1_ Net-_D2-Pad1_ Net-_D2-Pad1_ eSim_PNP
Q21  Net-_Q21-Pad1_ Net-_Q21-Pad2_ Net-_D2-Pad1_ eSim_PNP
Q23  Net-_Q23-Pad1_ Net-_D2-Pad1_ Net-_D2-Pad1_ eSim_PNP
Q26  Net-_Q26-Pad1_ Net-_Q26-Pad2_ Net-_D2-Pad1_ eSim_PNP
Q29  Net-_Q29-Pad1_ Net-_D2-Pad1_ Net-_D2-Pad1_ eSim_PNP
Q32  Net-_Q32-Pad1_ Net-_Q32-Pad2_ Net-_D2-Pad1_ eSim_PNP
Q34  Net-_Q34-Pad1_ Net-_D2-Pad1_ Net-_D2-Pad1_ eSim_PNP
Q37  Net-_Q37-Pad1_ Net-_Q37-Pad2_ Net-_D2-Pad1_ eSim_PNP
Q39  Net-_Q39-Pad1_ Net-_D2-Pad1_ Net-_D2-Pad1_ eSim_PNP
Q42  Net-_Q42-Pad1_ Net-_Q42-Pad2_ Net-_D2-Pad1_ eSim_PNP
Q45  Net-_D5-Pad1_ Net-_D2-Pad1_ Net-_D2-Pad1_ eSim_PNP
Q47  Net-_D6-Pad1_ Net-_Q47-Pad2_ Net-_D2-Pad1_ eSim_PNP
Q9  Net-_Q14-Pad1_ Net-_Q8-Pad1_ Net-_Q10-Pad1_ eSim_NPN
Q12  Net-_Q12-Pad1_ Net-_Q11-Pad1_ Net-_Q10-Pad1_ eSim_NPN
R2  Net-_Q8-Pad1_ Net-_D2-Pad1_ 800
R4  Net-_Q11-Pad1_ Net-_D2-Pad1_ 800
Q6  Net-_Q1-Pad2_ Net-_D2-Pad1_ Net-_Q5-Pad1_ eSim_NPN
Q5  Net-_Q5-Pad1_ Net-_D1-Pad2_ Net-_Q5-Pad3_ eSim_NPN
R1  Net-_Q5-Pad3_ Net-_D1-Pad2_ 5k
Q14  Net-_Q14-Pad1_ Net-_Q13-Pad1_ Net-_Q14-Pad3_ eSim_NPN
Q17  Net-_Q12-Pad1_ Net-_Q16-Pad1_ Net-_Q14-Pad3_ eSim_NPN
R6  Net-_Q13-Pad1_ Net-_D2-Pad1_ 1.6k
R8  Net-_Q16-Pad1_ Net-_D2-Pad1_ 1.6k
Q19  Net-_Q14-Pad1_ Net-_Q18-Pad1_ Net-_Q19-Pad3_ eSim_NPN
Q22  Net-_Q12-Pad1_ Net-_Q21-Pad1_ Net-_Q19-Pad3_ eSim_NPN
R10  Net-_Q18-Pad1_ Net-_D2-Pad1_ 3.2k
R12  Net-_Q21-Pad1_ Net-_D2-Pad1_ 3.2k
Q24  Net-_Q14-Pad1_ Net-_Q23-Pad1_ Net-_Q24-Pad3_ eSim_NPN
Q27  Net-_Q12-Pad1_ Net-_Q26-Pad1_ Net-_Q24-Pad3_ eSim_NPN
R14  Net-_Q23-Pad1_ Net-_D2-Pad1_ 6.4k
R17  Net-_Q26-Pad1_ Net-_D2-Pad1_ 6.4k
Q30  Net-_Q14-Pad1_ Net-_Q29-Pad1_ Net-_Q30-Pad3_ eSim_NPN
Q33  Net-_Q14-Pad1_ Net-_Q32-Pad1_ Net-_Q30-Pad3_ eSim_NPN
R18  Net-_Q29-Pad1_ Net-_D2-Pad1_ 6.4k
R20  Net-_Q32-Pad1_ Net-_D2-Pad1_ 6.4k
Q35  Net-_Q14-Pad1_ Net-_Q34-Pad1_ Net-_Q35-Pad3_ eSim_NPN
Q38  Net-_Q12-Pad1_ Net-_Q37-Pad1_ Net-_Q35-Pad3_ eSim_NPN
R22  Net-_Q34-Pad1_ Net-_D2-Pad1_ 6.4k
R23  Net-_Q37-Pad1_ Net-_D2-Pad1_ 6.4k
Q40  Net-_Q14-Pad1_ Net-_Q39-Pad1_ Net-_Q40-Pad3_ eSim_NPN
Q43  Net-_Q12-Pad1_ Net-_Q42-Pad1_ Net-_Q40-Pad3_ eSim_NPN
R24  Net-_Q39-Pad1_ Net-_D2-Pad1_ 6.4k
R25  Net-_Q42-Pad1_ Net-_D2-Pad1_ 6.4k
Q44  Net-_Q14-Pad1_ Net-_D5-Pad1_ Net-_Q44-Pad3_ eSim_NPN
D5  Net-_D5-Pad1_ Net-_D5-Pad2_ eSim_Diode
D6  Net-_D6-Pad1_ Net-_D5-Pad2_ eSim_Diode
R26  Net-_D5-Pad1_ Net-_D2-Pad1_ 6.4k
R27  Net-_D6-Pad1_ Net-_D2-Pad1_ 6.4k
Q48  Net-_Q12-Pad1_ Net-_D6-Pad1_ Net-_Q44-Pad3_ eSim_NPN
D4  Net-_D2-Pad1_ Net-_D4-Pad2_ eSim_Diode
Q10  Net-_Q10-Pad1_ Net-_D1-Pad2_ Net-_Q10-Pad3_ eSim_NPN
Q7  Net-_D1-Pad2_ Net-_D1-Pad2_ Net-_D4-Pad2_ eSim_PNP
Q15  Net-_Q14-Pad3_ Net-_D1-Pad2_ Net-_Q15-Pad3_ eSim_NPN
Q20  Net-_Q19-Pad3_ Net-_D1-Pad2_ Net-_Q20-Pad3_ eSim_NPN
Q25  Net-_Q24-Pad3_ Net-_D1-Pad2_ Net-_Q25-Pad3_ eSim_NPN
Q31  Net-_Q30-Pad3_ Net-_D2-Pad1_ Net-_Q31-Pad3_ eSim_NPN
Q36  Net-_Q35-Pad3_ Net-_D2-Pad1_ Net-_Q36-Pad3_ eSim_NPN
Q41  Net-_Q40-Pad3_ Net-_D2-Pad1_ Net-_Q36-Pad3_ eSim_NPN
Q46  Net-_D5-Pad2_ Net-_D2-Pad1_ Net-_Q36-Pad3_ eSim_NPN
Q28  Net-_Q28-Pad1_ Net-_D1-Pad2_ Net-_Q28-Pad3_ eSim_NPN
R3  Net-_Q10-Pad3_ Net-_D1-Pad2_ 10k
R7  Net-_Q15-Pad3_ Net-_R5-Pad1_ 10k
R11  Net-_Q20-Pad3_ Net-_R11-Pad2_ 10k
R15  Net-_Q25-Pad3_ Net-_R13-Pad1_ 10k
R19  Net-_Q31-Pad3_ Net-_Q28-Pad1_ 5k
R16  Net-_Q28-Pad3_ Net-_R13-Pad1_ 10k
R13  Net-_R13-Pad1_ Net-_R11-Pad2_ 5k
R9  Net-_R11-Pad2_ Net-_R5-Pad1_ 5k
R5  Net-_R5-Pad1_ Net-_D1-Pad2_ 5k
R21  Net-_Q36-Pad3_ Net-_Q28-Pad1_ 5k

.end
