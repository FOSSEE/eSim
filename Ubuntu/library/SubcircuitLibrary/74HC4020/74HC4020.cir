* C:\FOSSEE\eSim\library\SubcircuitLibrary\Asynch_counter_sub\Asynch_counter_sub.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 4/20/2025 7:24:35 PM

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U4  Net-_U10-Pad1_ Net-_U1-Pad2_ Net-_U10-Pad3_ Net-_U10-Pad4_ Net-_U3-Pad4_ Net-_U4-Pad6_ d_tff
U6  Net-_U10-Pad1_ Net-_U4-Pad6_ Net-_U10-Pad3_ Net-_U10-Pad4_ ? Net-_U6-Pad6_ d_tff
U8  Net-_U10-Pad1_ Net-_U6-Pad6_ Net-_U10-Pad3_ Net-_U10-Pad4_ ? Net-_U10-Pad2_ d_tff
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ Net-_U10-Pad3_ Net-_U10-Pad4_ Net-_U10-Pad5_ Net-_U10-Pad6_ d_tff
U12  Net-_U10-Pad1_ Net-_U10-Pad6_ Net-_U10-Pad3_ Net-_U10-Pad4_ Net-_U12-Pad5_ Net-_U12-Pad6_ d_tff
U14  Net-_U10-Pad1_ Net-_U12-Pad6_ Net-_U10-Pad3_ Net-_U10-Pad4_ Net-_U14-Pad5_ Net-_U14-Pad6_ d_tff
U16  Net-_U10-Pad1_ Net-_U14-Pad6_ Net-_U10-Pad3_ Net-_U10-Pad4_ Net-_U16-Pad5_ Net-_U16-Pad6_ d_tff
U5  Net-_U10-Pad1_ Net-_U16-Pad6_ Net-_U10-Pad3_ Net-_U10-Pad4_ Net-_U3-Pad5_ Net-_U5-Pad6_ d_tff
U7  Net-_U10-Pad1_ Net-_U5-Pad6_ Net-_U10-Pad3_ Net-_U10-Pad4_ Net-_U3-Pad6_ Net-_U7-Pad6_ d_tff
U9  Net-_U10-Pad1_ Net-_U7-Pad6_ Net-_U10-Pad3_ Net-_U10-Pad4_ Net-_U3-Pad7_ Net-_U11-Pad2_ d_tff
U11  Net-_U10-Pad1_ Net-_U11-Pad2_ Net-_U10-Pad3_ Net-_U10-Pad4_ Net-_U11-Pad5_ Net-_U11-Pad6_ d_tff
U13  Net-_U10-Pad1_ Net-_U11-Pad6_ Net-_U10-Pad3_ Net-_U10-Pad4_ Net-_U13-Pad5_ Net-_U13-Pad6_ d_tff
U15  Net-_U10-Pad1_ Net-_U13-Pad6_ Net-_U10-Pad3_ Net-_U10-Pad4_ Net-_U15-Pad5_ Net-_U15-Pad6_ d_tff
U17  Net-_U10-Pad1_ Net-_U15-Pad6_ Net-_U10-Pad3_ Net-_U10-Pad4_ Net-_U17-Pad5_ ? d_tff
U3  Net-_U10-Pad3_ Net-_U1-Pad1_ Net-_U10-Pad4_ Net-_U3-Pad4_ Net-_U3-Pad5_ Net-_U3-Pad6_ Net-_U3-Pad7_ Net-_U10-Pad5_ Net-_U11-Pad5_ Net-_U12-Pad5_ Net-_U13-Pad5_ Net-_U14-Pad5_ Net-_U15-Pad5_ Net-_U16-Pad5_ Net-_U17-Pad5_ PORT
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ d_inverter
U2  Net-_U2-Pad1_ Net-_U10-Pad1_ adc_bridge_1
v1  Net-_U2-Pad1_ GND 5

.end
