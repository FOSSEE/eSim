* C:\FOSSEE\eSim\library\SubcircuitLibrary\LM317_sub\LM317_sub.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 05/27/24 14:52:45

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
J1  Net-_J1-Pad1_ Net-_C1-Pad2_ Net-_J1-Pad3_ eSim_NJF
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad1_ Net-_Q1-Pad3_ eSim_PNP
Q2  Net-_Q1-Pad1_ Net-_Q2-Pad2_ Net-_Q2-Pad3_ eSim_NPN
Q3  Net-_Q2-Pad2_ Net-_Q1-Pad1_ Net-_Q3-Pad3_ eSim_PNP
Q4  Net-_Q4-Pad1_ Net-_Q2-Pad2_ Net-_C1-Pad2_ eSim_NPN
Q7  Net-_Q7-Pad1_ Net-_Q4-Pad1_ Net-_Q7-Pad3_ eSim_NPN
Q5  Net-_C1-Pad2_ Net-_Q4-Pad1_ Net-_Q5-Pad3_ eSim_PNP
Q6  Net-_Q6-Pad1_ Net-_Q1-Pad1_ Net-_Q6-Pad3_ eSim_PNP
Q8  Net-_Q10-Pad2_ Net-_Q7-Pad1_ Net-_Q5-Pad3_ eSim_PNP
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
Q11  Net-_C1-Pad2_ Net-_Q11-Pad2_ Net-_Q10-Pad1_ eSim_PNP
Q9  Net-_Q10-Pad1_ Net-_Q1-Pad1_ Net-_Q9-Pad3_ eSim_PNP
Q13  Net-_Q12-Pad2_ Net-_Q1-Pad1_ Net-_Q13-Pad3_ eSim_PNP
Q12  Net-_J1-Pad1_ Net-_Q12-Pad2_ Net-_Q11-Pad2_ eSim_NPN
Q14  Net-_C1-Pad2_ Net-_C1-Pad1_ Net-_Q12-Pad2_ eSim_PNP
Q16  Net-_C1-Pad1_ Net-_C1-Pad2_ Net-_Q16-Pad3_ eSim_NPN
Q18  Net-_Q15-Pad2_ Net-_C1-Pad2_ Net-_Q18-Pad3_ eSim_NPN
Q15  Net-_C1-Pad1_ Net-_Q15-Pad2_ Net-_Q10-Pad1_ eSim_PNP
Q17  Net-_Q15-Pad2_ Net-_Q15-Pad2_ Net-_Q10-Pad1_ eSim_PNP
Q19  Net-_C1-Pad2_ Net-_C3-Pad1_ Net-_Q10-Pad1_ eSim_PNP
Q20  Net-_C3-Pad1_ Net-_C3-Pad2_ Net-_C1-Pad2_ eSim_NPN
Q23  Net-_Q21-Pad2_ Net-_Q10-Pad1_ Net-_Q23-Pad3_ eSim_NPN
Q26  Net-_J1-Pad1_ Net-_Q26-Pad2_ Net-_Q26-Pad3_ eSim_NPN
Q27  Net-_J1-Pad1_ Net-_Q26-Pad3_ Net-_Q27-Pad3_ eSim_NPN
Q22  Net-_Q22-Pad1_ Net-_Q22-Pad2_ Net-_Q22-Pad3_ eSim_NPN
Q25  Net-_Q22-Pad1_ Net-_Q22-Pad2_ Net-_Q25-Pad3_ eSim_NPN
Q21  Net-_Q10-Pad1_ Net-_Q21-Pad2_ Net-_J1-Pad1_ eSim_PNP
Q24  Net-_Q21-Pad2_ Net-_Q21-Pad2_ Net-_J1-Pad1_ eSim_PNP
U5  Net-_J1-Pad1_ Net-_C1-Pad2_ Net-_R16-Pad2_ PORT
U3  Net-_R26-Pad1_ Net-_J1-Pad1_ zener
U4  Net-_Q25-Pad3_ Net-_R26-Pad2_ zener
U2  Net-_C2-Pad2_ Net-_C1-Pad2_ zener
U1  Net-_C1-Pad2_ Net-_J1-Pad3_ zener
R13  Net-_J1-Pad1_ Net-_Q13-Pad3_ 5.6k
R10  Net-_J1-Pad1_ Net-_Q9-Pad3_ 82
R6  Net-_J1-Pad1_ Net-_Q6-Pad3_ 190
R4  Net-_J1-Pad1_ Net-_Q3-Pad3_ 310
R2  Net-_J1-Pad1_ Net-_Q1-Pad3_ 310
R1  Net-_J1-Pad3_ Net-_Q2-Pad2_ 200k
R5  Net-_Q2-Pad2_ Net-_Q4-Pad1_ 130
R3  Net-_Q2-Pad3_ Net-_C1-Pad2_ 180
R7  Net-_Q6-Pad1_ Net-_Q7-Pad1_ 12.4k
R21  Net-_Q10-Pad1_ Net-_Q26-Pad2_ 370
R22  Net-_Q23-Pad3_ Net-_Q26-Pad3_ 130
R19  Net-_Q10-Pad1_ Net-_Q22-Pad2_ 12k
R18  Net-_C3-Pad2_ Net-_Q22-Pad1_ 13k
R20  Net-_Q22-Pad2_ Net-_Q22-Pad1_ 400
R23  Net-_Q26-Pad3_ Net-_C1-Pad2_ 160
R27  Net-_Q25-Pad3_ Net-_Q22-Pad3_ 160
R25  Net-_Q27-Pad3_ Net-_Q22-Pad3_ 3
R24  Net-_Q27-Pad3_ Net-_C1-Pad2_ 0.14
R26  Net-_R26-Pad1_ Net-_R26-Pad2_ 18k
R8  Net-_Q7-Pad3_ Net-_C1-Pad2_ 4.1k
R9  Net-_Q10-Pad2_ Net-_C1-Pad2_ 5.8k
R11  Net-_Q10-Pad3_ Net-_C1-Pad2_ 72
R12  Net-_Q11-Pad2_ Net-_C1-Pad2_ 5.1k
R14  Net-_Q16-Pad3_ Net-_C2-Pad2_ 12k
R15  Net-_Q18-Pad3_ Net-_Q16-Pad3_ 2.4k
R16  Net-_C2-Pad2_ Net-_R16-Pad2_ 50
R17  Net-_Q10-Pad1_ Net-_C3-Pad1_ 6.7k
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 30pF
C2  Net-_C1-Pad1_ Net-_C2-Pad2_ 30pF
C3  Net-_C3-Pad1_ Net-_C3-Pad2_ 5pF

.end
