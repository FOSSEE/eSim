.title KiCad schematic
M8 Net-_M12-Pad2_ Net-_D3-Pad1_ gnd gnd eSim_MOS_N
U1 outputA inv_inputA noninv_inputA gnd noninv_inputB inv_inputB outputB vcc PORT
R2 Net-_M1-Pad2_ Net-_M4-Pad2_ 2k
D1 noninv_inputA Net-_D1-Pad2_ eSim_Diode
M1 Net-_M1-Pad1_ Net-_M1-Pad2_ vcc vcc eSim_MOS_P
M5 Net-_D1-Pad2_ noninv_inputA gnd vcc eSim_MOS_P
D5 inv_inputA Net-_D4-Pad2_ eSim_Diode
D4 Net-_D4-Pad1_ Net-_D4-Pad2_ eSim_Diode
M10 vcc Net-_M10-Pad2_ Net-_M10-Pad3_ vcc eSim_MOS_P
Q1 vcc gnd Net-_M2-Pad1_ eSim_PNP
M2 Net-_M2-Pad1_ Net-_M2-Pad1_ Net-_M1-Pad1_ gnd eSim_MOS_N
M4 Net-_M3-Pad1_ Net-_M4-Pad2_ vcc Net-_M2-Pad1_ eSim_MOS_P
M9 Net-_M12-Pad2_ Net-_D4-Pad2_ Net-_M10-Pad3_ vcc eSim_MOS_P
R3 Net-_M6-Pad1_ vcc 10k
M6 Net-_M6-Pad1_ Net-_M10-Pad2_ Net-_D4-Pad1_ Net-_D2-Pad1_ eSim_MOS_P
D2 Net-_D2-Pad1_ Net-_D1-Pad2_ eSim_Diode
M7 Net-_M10-Pad3_ Net-_D1-Pad2_ Net-_D3-Pad1_ vcc eSim_MOS_P
M11 gnd inv_inputA Net-_D4-Pad2_ vcc eSim_MOS_P
M12 Net-_M12-Pad1_ Net-_M12-Pad2_ gnd gnd eSim_MOS_N
M13 vcc Net-_M10-Pad2_ Net-_M12-Pad1_ vcc eSim_MOS_P
M14 outputA Net-_M12-Pad1_ gnd gnd eSim_MOS_N
Q2 vcc gnd Net-_M25-Pad4_ eSim_PNP
M26 Net-_M25-Pad1_ Net-_M25-Pad4_ gnd gnd eSim_MOS_N
M27 Net-_M25-Pad4_ Net-_M25-Pad4_ Net-_M27-Pad3_ gnd eSim_MOS_N
R6 gnd Net-_M25-Pad4_ 4.6k
R5 Net-_M28-Pad2_ Net-_M25-Pad2_ 2k
M25 Net-_M25-Pad1_ Net-_M25-Pad2_ vcc Net-_M25-Pad4_ eSim_MOS_P
M28 Net-_M27-Pad3_ Net-_M28-Pad2_ vcc vcc eSim_MOS_P
M18 gnd inv_inputB Net-_D6-Pad2_ vcc eSim_MOS_P
M21 Net-_M17-Pad2_ Net-_D8-Pad1_ gnd gnd eSim_MOS_N
R1 gnd Net-_M2-Pad1_ 4.6k
D9 Net-_D9-Pad1_ Net-_D10-Pad2_ eSim_Diode
M24 Net-_D10-Pad2_ noninv_inputB gnd vcc eSim_MOS_P
D10 noninv_inputB Net-_D10-Pad2_ eSim_Diode
D8 Net-_D8-Pad1_ gnd eSim_Diode
D3 Net-_D3-Pad1_ gnd eSim_Diode
M3 Net-_M3-Pad1_ Net-_M2-Pad1_ gnd gnd eSim_MOS_N
M16 vcc Net-_M16-Pad2_ Net-_M15-Pad2_ vcc eSim_MOS_P
M19 vcc Net-_M16-Pad2_ Net-_M19-Pad3_ vcc eSim_MOS_P
D7 Net-_D7-Pad1_ Net-_D6-Pad2_ eSim_Diode
D6 inv_inputB Net-_D6-Pad2_ eSim_Diode
M17 Net-_M15-Pad2_ Net-_M17-Pad2_ gnd gnd eSim_MOS_N
M15 outputB Net-_M15-Pad2_ gnd gnd eSim_MOS_N
M20 Net-_M17-Pad2_ Net-_D6-Pad2_ Net-_M19-Pad3_ vcc eSim_MOS_P
R4 Net-_M23-Pad1_ vcc 10k
M23 Net-_M23-Pad1_ Net-_M16-Pad2_ Net-_D7-Pad1_ Net-_D9-Pad1_ eSim_MOS_P
M22 Net-_M19-Pad3_ Net-_D10-Pad2_ Net-_D8-Pad1_ vcc eSim_MOS_P
.end
