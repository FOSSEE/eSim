* C:\FOSSEE\eSim\library\SubcircuitLibrary\ICL8038\ICL8038.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 09/14/22 23:03:48

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
Q51  Net-_Q10-Pad1_ Net-_Q51-Pad2_ Net-_Q49-Pad2_ eSim_NPN
Q49  Net-_D4-Pad2_ Net-_Q49-Pad2_ Net-_Q49-Pad3_ eSim_PNP
Q47  Net-_Q10-Pad1_ Net-_Q47-Pad2_ Net-_Q45-Pad2_ eSim_NPN
Q45  Net-_D4-Pad2_ Net-_Q45-Pad2_ Net-_Q45-Pad3_ eSim_PNP
Q43  Net-_Q10-Pad1_ Net-_Q43-Pad2_ Net-_Q41-Pad2_ eSim_NPN
Q41  Net-_D4-Pad2_ Net-_Q41-Pad2_ Net-_Q41-Pad3_ eSim_PNP
Q39  Net-_Q10-Pad1_ Net-_Q39-Pad2_ Net-_Q37-Pad2_ eSim_NPN
Q37  Net-_D4-Pad2_ Net-_Q37-Pad2_ Net-_Q37-Pad3_ eSim_PNP
Q38  Net-_Q10-Pad1_ Net-_Q38-Pad2_ Net-_Q38-Pad3_ eSim_NPN
Q40  Net-_D4-Pad2_ Net-_Q40-Pad2_ Net-_Q38-Pad2_ eSim_PNP
Q44  Net-_D4-Pad2_ Net-_Q44-Pad2_ Net-_Q42-Pad2_ eSim_PNP
Q42  Net-_Q10-Pad1_ Net-_Q42-Pad2_ Net-_Q42-Pad3_ eSim_NPN
Q46  Net-_Q10-Pad1_ Net-_Q46-Pad2_ Net-_Q46-Pad3_ eSim_NPN
Q48  Net-_D4-Pad2_ Net-_Q48-Pad2_ Net-_Q46-Pad2_ eSim_PNP
Q52  Net-_D4-Pad2_ Net-_Q52-Pad2_ Net-_Q50-Pad2_ eSim_PNP
Q50  Net-_Q10-Pad1_ Net-_Q50-Pad2_ Net-_Q49-Pad3_ eSim_NPN
Q33  Net-_Q10-Pad1_ Net-_Q33-Pad2_ Net-_Q31-Pad2_ eSim_NPN
Q31  Net-_Q10-Pad1_ Net-_Q31-Pad2_ Net-_Q27-Pad3_ eSim_NPN
Q24  Net-_Q22-Pad2_ Net-_Q16-Pad3_ Net-_Q24-Pad3_ eSim_NPN
Q27  Net-_Q22-Pad2_ Net-_Q24-Pad3_ Net-_Q27-Pad3_ eSim_NPN
Q28  Net-_D8-Pad1_ Net-_Q25-Pad3_ Net-_Q28-Pad3_ eSim_PNP
Q25  Net-_D8-Pad1_ Net-_Q16-Pad3_ Net-_Q25-Pad3_ eSim_PNP
Q32  Net-_D4-Pad2_ Net-_Q32-Pad2_ Net-_Q28-Pad3_ eSim_PNP
Q34  Net-_D4-Pad2_ Net-_Q34-Pad2_ Net-_Q32-Pad2_ eSim_PNP
Q29  Net-_Q29-Pad1_ Net-_Q29-Pad1_ Net-_Q29-Pad3_ eSim_NPN
Q35  Net-_Q10-Pad1_ Net-_Q29-Pad1_ Net-_Q35-Pad3_ eSim_NPN
Q30  Net-_D4-Pad2_ Net-_Q26-Pad3_ Net-_Q29-Pad3_ eSim_PNP
Q36  Net-_D4-Pad2_ Net-_Q26-Pad3_ Net-_Q35-Pad3_ eSim_PNP
Q22  Net-_D9-Pad1_ Net-_Q22-Pad2_ Net-_Q10-Pad1_ eSim_PNP
Q14  Net-_Q14-Pad1_ Net-_Q14-Pad2_ Net-_Q10-Pad1_ eSim_PNP
Q15  Net-_Q10-Pad1_ Net-_Q14-Pad1_ Net-_Q15-Pad3_ eSim_NPN
Q16  Net-_Q15-Pad3_ Net-_Q15-Pad3_ Net-_Q16-Pad3_ eSim_NPN
Q8  Net-_Q10-Pad2_ Net-_Q14-Pad2_ Net-_Q10-Pad1_ eSim_PNP
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
Q11  Net-_Q10-Pad3_ Net-_Q10-Pad3_ Net-_D5-Pad2_ eSim_NPN
Q4  Net-_Q10-Pad1_ Net-_Q3-Pad3_ Net-_Q14-Pad2_ eSim_NPN
Q3  Net-_Q14-Pad2_ Net-_Q14-Pad2_ Net-_Q3-Pad3_ eSim_NPN
Q6  Net-_Q14-Pad2_ Net-_Q10-Pad3_ Net-_Q6-Pad3_ eSim_NPN
Q17  Net-_Q16-Pad3_ Net-_D5-Pad2_ Net-_Q12-Pad1_ eSim_NPN
Q18  Net-_Q12-Pad1_ Net-_Q12-Pad1_ Net-_Q18-Pad3_ eSim_NPN
Q12  Net-_Q12-Pad1_ Net-_Q12-Pad1_ Net-_Q12-Pad3_ eSim_NPN
Q7  Net-_D5-Pad2_ Net-_Q12-Pad1_ Net-_Q7-Pad3_ eSim_NPN
Q1  Net-_Q1-Pad1_ Net-_D1-Pad1_ Net-_Q1-Pad3_ eSim_NPN
Q5  Net-_Q1-Pad1_ Net-_D6-Pad2_ Net-_Q5-Pad3_ eSim_NPN
Q2  Net-_Q2-Pad1_ Net-_Q2-Pad2_ Net-_D4-Pad2_ eSim_NPN
D1  Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
D2  Net-_D1-Pad2_ Net-_D2-Pad2_ eSim_Diode
D3  Net-_D2-Pad2_ Net-_D3-Pad2_ eSim_Diode
D4  Net-_D3-Pad2_ Net-_D4-Pad2_ eSim_Diode
R1  Net-_Q1-Pad1_ Net-_D1-Pad1_ 30k
R4  Net-_Q5-Pad3_ Net-_Q2-Pad2_ 270
R5  Net-_Q2-Pad2_ Net-_D4-Pad2_ 2.7k
R10  Net-_D6-Pad1_ Net-_D5-Pad1_ 470
R11  Net-_D7-Pad1_ Net-_D6-Pad2_ 27k
Q21  Net-_D6-Pad1_ Net-_D9-Pad1_ Net-_D4-Pad2_ eSim_NPN
R8  Net-_Q1-Pad3_ Net-_D6-Pad2_ 620
R13  Net-_Q1-Pad3_ Net-_D6-Pad1_ 1.8k
R9  Net-_Q12-Pad3_ Net-_D4-Pad2_ 100
R7  Net-_Q7-Pad3_ Net-_D4-Pad2_ 100
R12  Net-_Q18-Pad3_ Net-_D4-Pad2_ 100
Q26  Net-_Q10-Pad1_ Net-_Q23-Pad3_ Net-_Q26-Pad3_ eSim_NPN
Q23  Net-_Q10-Pad1_ Net-_Q15-Pad3_ Net-_Q23-Pad3_ eSim_NPN
R16  Net-_Q23-Pad3_ Net-_Q26-Pad3_ 27k
R18  Net-_Q26-Pad3_ Net-_D4-Pad2_ 27k
R20  Net-_Q10-Pad1_ Net-_Q29-Pad1_ 27k
R14  Net-_D4-Pad2_ Net-_D8-Pad1_ 4.7k
R15  Net-_D4-Pad2_ Net-_D9-Pad1_ 4.7k
R6  Net-_Q6-Pad3_ Net-_D5-Pad2_ 40k
R2  Net-_Q10-Pad1_ Net-_R2-Pad2_ 11k
R3  Net-_R2-Pad2_ Net-_D4-Pad2_ 39k
R17  Net-_Q10-Pad1_ Net-_Q22-Pad2_ 4k
R22  Net-_Q10-Pad1_ Net-_Q33-Pad2_ 5k
R23  Net-_Q33-Pad2_ Net-_Q34-Pad2_ 5k
R24  Net-_Q34-Pad2_ Net-_D4-Pad2_ 5k
R19  Net-_Q28-Pad3_ Net-_Q10-Pad1_ 15k
R21  Net-_D4-Pad2_ Net-_Q27-Pad3_ 10k
R26  Net-_Q45-Pad3_ Net-_Q49-Pad3_ 800
R27  Net-_Q41-Pad3_ Net-_Q49-Pad3_ 2.7k
R28  Net-_Q37-Pad3_ Net-_Q49-Pad3_ 10k
R31  Net-_Q46-Pad3_ Net-_Q49-Pad3_ 800
R30  Net-_Q42-Pad3_ Net-_Q49-Pad3_ 2.7k
R29  Net-_Q38-Pad3_ Net-_Q49-Pad3_ 10k
R35  Net-_Q10-Pad1_ Net-_Q42-Pad2_ 33k
R37  Net-_Q10-Pad1_ Net-_Q46-Pad2_ 33k
R39  Net-_Q10-Pad1_ Net-_Q50-Pad2_ 33k
R32  Net-_Q37-Pad2_ Net-_D4-Pad2_ 33k
R34  Net-_Q41-Pad2_ Net-_D4-Pad2_ 33k
R36  Net-_Q45-Pad2_ Net-_D4-Pad2_ 33k
R38  Net-_Q49-Pad2_ Net-_D4-Pad2_ 33k
R44  Net-_Q39-Pad2_ Net-_Q40-Pad2_ 1600
R45  Net-_Q40-Pad2_ Net-_Q44-Pad2_ 330
R46  Net-_Q44-Pad2_ Net-_Q48-Pad2_ 375
R47  Net-_Q48-Pad2_ Net-_Q52-Pad2_ 200
R48  Net-_Q52-Pad2_ Net-_D4-Pad2_ 5.6k
R43  Net-_Q43-Pad2_ Net-_Q39-Pad2_ 330
R42  Net-_Q47-Pad2_ Net-_Q43-Pad2_ 375
R41  Net-_Q51-Pad2_ Net-_Q47-Pad2_ 200
R40  Net-_Q10-Pad1_ Net-_Q51-Pad2_ 5.2k
R25  Net-_Q35-Pad3_ Net-_Q49-Pad3_ 1k
U1  Net-_Q2-Pad1_ Net-_R2-Pad2_ Net-_Q3-Pad3_ Net-_Q10-Pad1_ Net-_Q10-Pad1_ Net-_Q16-Pad3_ Net-_D4-Pad2_ Net-_Q35-Pad3_ Net-_Q49-Pad3_ Net-_Q10-Pad1_ Net-_Q51-Pad2_ Net-_Q52-Pad2_ ? ? PORT
R33  Net-_Q10-Pad1_ Net-_Q38-Pad2_ 33k
Q9  Net-_D5-Pad2_ Net-_D5-Pad1_ Net-_D4-Pad2_ eSim_NPN
D5  Net-_D5-Pad1_ Net-_D5-Pad2_ eSim_Diode
D9  Net-_D9-Pad1_ Net-_D6-Pad1_ eSim_Diode
Q19  Net-_D7-Pad1_ Net-_D8-Pad1_ Net-_D4-Pad2_ eSim_NPN
D8  Net-_D8-Pad1_ Net-_D7-Pad1_ eSim_Diode
Q13  Net-_D6-Pad2_ Net-_D6-Pad1_ Net-_D4-Pad2_ eSim_NPN
D6  Net-_D6-Pad1_ Net-_D6-Pad2_ eSim_Diode
Q20  Net-_D6-Pad1_ Net-_D7-Pad1_ Net-_D4-Pad2_ eSim_NPN
D7  Net-_D7-Pad1_ Net-_D6-Pad1_ eSim_Diode

.end
