* C:\FOSSEE\eSim\library\SubcircuitLibrary\LM307\LM307.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 09/09/22 20:36:04

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
Q1  Net-_J1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
Q9  Net-_J1-Pad1_ Net-_Q9-Pad2_ Net-_Q10-Pad3_ eSim_NPN
Q2  Net-_Q2-Pad1_ Net-_Q10-Pad2_ Net-_Q1-Pad3_ eSim_PNP
Q5  Net-_Q10-Pad2_ Net-_Q10-Pad2_ Net-_Q1-Pad3_ eSim_PNP
Q10  Net-_C1-Pad2_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_PNP
Q7  Net-_Q10-Pad2_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_PNP
Q18  Net-_Q18-Pad1_ Net-_Q13-Pad1_ Net-_J1-Pad1_ eSim_PNP
Q17  Net-_Q13-Pad1_ Net-_Q13-Pad1_ Net-_J1-Pad1_ eSim_PNP
Q4  Net-_Q13-Pad1_ Net-_Q2-Pad1_ Net-_Q11-Pad2_ eSim_NPN
Q3  Net-_Q2-Pad1_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_NPN
R1  Net-_Q11-Pad2_ Net-_Q11-Pad3_ 40k
Q11  Net-_C1-Pad2_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_NPN
Q6  Net-_Q10-Pad2_ Net-_Q6-Pad2_ Net-_Q6-Pad3_ eSim_NPN
Q8  Net-_Q13-Pad1_ Net-_Q12-Pad1_ Net-_Q6-Pad2_ eSim_NPN
R2  Net-_Q6-Pad3_ Net-_R2-Pad2_ 5k
R3  Net-_Q6-Pad2_ Net-_R2-Pad2_ 20k
R4  Net-_R2-Pad2_ Net-_J1-Pad2_ 250
R7  Net-_Q14-Pad1_ Net-_C1-Pad2_ 120
J1  Net-_J1-Pad1_ Net-_J1-Pad2_ Net-_J1-Pad3_ jfet_n
R5  Net-_J1-Pad3_ Net-_Q12-Pad1_ 450
Q12  Net-_Q12-Pad1_ Net-_Q12-Pad2_ Net-_J1-Pad2_ eSim_NPN
Q13  Net-_Q13-Pad1_ Net-_J1-Pad3_ Net-_Q12-Pad2_ eSim_NPN
R6  Net-_Q12-Pad2_ Net-_J1-Pad2_ 10k
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 30p
Q14  Net-_Q14-Pad1_ Net-_Q11-Pad3_ Net-_J1-Pad2_ eSim_NPN
Q15  Net-_Q13-Pad1_ Net-_Q14-Pad1_ Net-_Q15-Pad3_ eSim_NPN
R8  Net-_Q11-Pad3_ Net-_Q15-Pad3_ 40k
Q16  Net-_Q16-Pad1_ Net-_Q15-Pad3_ Net-_Q11-Pad3_ eSim_NPN
Q19  Net-_Q18-Pad1_ Net-_Q18-Pad1_ Net-_Q19-Pad3_ eSim_NPN
Q21  Net-_Q18-Pad1_ Net-_Q21-Pad2_ Net-_C2-Pad1_ eSim_NPN
Q23  Net-_J1-Pad1_ Net-_Q18-Pad1_ Net-_Q21-Pad2_ eSim_NPN
R13  Net-_C2-Pad1_ Net-_Q21-Pad2_ 25
C2  Net-_C2-Pad1_ Net-_C1-Pad1_ 2p
R14  Net-_Q22-Pad3_ Net-_Q21-Pad2_ 65
R12  Net-_C1-Pad1_ Net-_Q22-Pad3_ 7.5k
R9  Net-_C1-Pad1_ Net-_Q16-Pad1_ 620
Q20  Net-_J1-Pad2_ Net-_Q16-Pad1_ Net-_Q19-Pad3_ eSim_PNP
Q22  Net-_Q22-Pad1_ Net-_Q16-Pad1_ Net-_Q22-Pad3_ eSim_PNP
Q24  Net-_Q22-Pad3_ Net-_Q22-Pad1_ Net-_J1-Pad2_ eSim_NPN
R10  Net-_Q22-Pad1_ Net-_Q11-Pad3_ 80k
R11  Net-_Q11-Pad3_ Net-_J1-Pad2_ 650
U1  Net-_Q1-Pad2_ Net-_Q9-Pad2_ Net-_J1-Pad1_ Net-_J1-Pad2_ Net-_C2-Pad1_ ? ? ? PORT

.end
