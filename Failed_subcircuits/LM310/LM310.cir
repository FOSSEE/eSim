* C:\FOSSEE\eSim\library\SubcircuitLibrary\LM310\LM310.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 07/29/22 23:09:57

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
R3  Net-_R1-Pad1_ Net-_J1-Pad1_ 500
R4  Net-_J1-Pad1_ Net-_R4-Pad2_ 500
R1  Net-_R1-Pad1_ Net-_Q4-Pad3_ 1k
R5  Net-_R4-Pad2_ Net-_Q5-Pad3_ 1k
Q4  Net-_Q3-Pad1_ Net-_Q4-Pad2_ Net-_Q4-Pad3_ eSim_PNP
Q5  Net-_Q4-Pad2_ Net-_Q4-Pad2_ Net-_Q5-Pad3_ eSim_PNP
Q9  Net-_C1-Pad1_ Net-_Q3-Pad1_ Net-_Q4-Pad2_ eSim_PNP
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 10p
Q14  Net-_C1-Pad1_ Net-_Q14-Pad2_ Net-_Q10-Pad1_ eSim_NPN
Q17  Net-_J1-Pad1_ Net-_C1-Pad1_ Net-_Q14-Pad2_ eSim_NPN
Q18  Net-_J1-Pad1_ Net-_Q14-Pad2_ Net-_D1-Pad2_ eSim_NPN
R12  Net-_Q14-Pad2_ Net-_D1-Pad2_ 3k
Q16  Net-_C1-Pad1_ Net-_D1-Pad2_ Net-_Q13-Pad1_ eSim_NPN
R13  Net-_D1-Pad2_ Net-_Q13-Pad1_ 25
R10  Net-_C1-Pad2_ Net-_Q13-Pad1_ 5k
Q12  Net-_Q10-Pad1_ Net-_C1-Pad2_ Net-_Q10-Pad2_ eSim_NPN
R9  Net-_Q10-Pad2_ Net-_Q11-Pad1_ 200k
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
Q7  Net-_D1-Pad2_ Net-_Q6-Pad3_ Net-_Q10-Pad3_ eSim_NPN
Q11  Net-_Q11-Pad1_ Net-_Q11-Pad1_ Net-_Q11-Pad3_ eSim_NPN
R7  Net-_Q10-Pad3_ Net-_Q11-Pad3_ 150
Q6  Net-_D1-Pad2_ Net-_D1-Pad1_ Net-_Q6-Pad3_ eSim_NPN
R6  Net-_Q6-Pad3_ Net-_Q11-Pad1_ 200k
D1  Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
Q13  Net-_Q13-Pad1_ Net-_Q13-Pad1_ Net-_D1-Pad1_ eSim_NPN
Q8  Net-_Q11-Pad3_ Net-_J1-Pad3_ Net-_Q8-Pad3_ eSim_NPN
J1  Net-_J1-Pad1_ Net-_J1-Pad2_ Net-_J1-Pad3_ jfet_n
Q3  Net-_Q3-Pad1_ Net-_J1-Pad3_ Net-_Q3-Pad3_ eSim_NPN
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad1_ Net-_J1-Pad2_ eSim_NPN
R2  Net-_Q3-Pad3_ Net-_J1-Pad2_ 3k
R8  Net-_Q8-Pad3_ Net-_J1-Pad2_ 1.5k
Q15  Net-_Q13-Pad1_ Net-_Q15-Pad2_ Net-_Q15-Pad3_ eSim_NPN
R11  Net-_Q15-Pad3_ Net-_J1-Pad2_ 200
Q2  Net-_Q15-Pad2_ Net-_Q1-Pad1_ Net-_J1-Pad3_ eSim_PNP
U1  Net-_D1-Pad1_ Net-_R1-Pad1_ Net-_R4-Pad2_ Net-_Q15-Pad3_ Net-_J1-Pad2_ ? Net-_J1-Pad1_ Net-_Q13-Pad1_ PORT

.end
