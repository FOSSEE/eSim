* C:\esim_1\eSim\src\SubcircuitLibrary\LM565\LM565.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 03/31/19 18:47:10

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
R1  +Vcc Net-_Q1-Pad1_ 7.2k
R3  +Vcc Net-_Q14-Pad2_ 7.2k
Q4  Net-_Q14-Pad2_ Net-_Q14-Pad2_ Net-_Q1-Pad1_ eSim_NPN
Q5  Net-_Q1-Pad1_ Net-_Q1-Pad1_ Net-_Q14-Pad2_ eSim_NPN
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad1_ +Vcc eSim_NPN
R4  +Vcc Net-_Q3-Pad2_ 5.7k
R6  +Vcc Reference_output 1.75k
R7  Reference_output Net-_Q1-Pad2_ 3.8k
Q12  +Vcc Net-_Q1-Pad1_ Net-_Q12-Pad3_ eSim_NPN
Q14  Vco_control_voltage Net-_Q14-Pad2_ Net-_Q14-Pad3_ eSim_NPN
R12  +Vcc Vco_control_voltage 3.6K
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
Q3  Net-_Q14-Pad2_ Net-_Q3-Pad2_ Net-_Q1-Pad3_ eSim_NPN
Q7  Net-_Q1-Pad1_ Net-_Q3-Pad2_ Net-_Q7-Pad3_ eSim_NPN
Q9  Net-_Q14-Pad2_ Net-_Q1-Pad2_ Net-_Q7-Pad3_ eSim_NPN
R5  Net-_Q3-Pad2_ -Vcc 13k
Q2  Net-_Q1-Pad3_ Input Net-_Q2-Pad3_ eSim_NPN
Q8  Net-_Q7-Pad3_ Input Net-_Q2-Pad3_ eSim_NPN
Q6  Net-_Q2-Pad3_ Net-_Q11-Pad1_ Net-_Q6-Pad3_ eSim_NPN
R2  Net-_Q6-Pad3_ -Vcc 200
R8  Net-_Q1-Pad2_ Net-_Q11-Pad1_ 8.1K
R10  Net-_Q12-Pad3_ Net-_Q13-Pad1_ 1K
R13  Net-_Q14-Pad3_ Net-_Q13-Pad1_ 1K
Q13  Net-_Q13-Pad1_ Net-_Q11-Pad1_ Net-_Q13-Pad3_ eSim_NPN
Q11  Net-_Q11-Pad1_ Net-_Q11-Pad1_ Net-_Q11-Pad3_ eSim_NPN
R9  Net-_Q11-Pad3_ -Vcc 200
R11  Net-_Q13-Pad3_ -Vcc 205
Q16  Timming_resistor Vco_control_voltage Net-_Q15-Pad2_ eSim_NPN
Q18  Net-_Q15-Pad2_ Net-_Q18-Pad2_ Net-_Q17-Pad1_ eSim_NPN
Q20  Net-_Q18-Pad2_ Net-_Q18-Pad2_ Net-_Q17-Pad1_ eSim_NPN
Q17  Net-_Q17-Pad1_ Net-_Q17-Pad1_ Net-_Q17-Pad3_ eSim_NPN
Q21  Timing_capacitor Timing_capacitor Net-_Q17-Pad1_ eSim_PNP
Q22  Timing_capacitor Net-_Q17-Pad3_ Net-_Q19-Pad2_ eSim_NPN
Q19  Net-_Q17-Pad3_ Net-_Q19-Pad2_ Net-_Q19-Pad3_ eSim_NPN
Q23  Net-_Q19-Pad2_ Net-_Q19-Pad2_ Net-_Q23-Pad3_ eSim_NPN
R14  Net-_Q19-Pad3_ Net-_Q24-Pad1_ 530
R15  Net-_Q23-Pad3_ Net-_Q24-Pad1_ 530
Q25  +Vcc Timing_capacitor Net-_Q25-Pad3_ eSim_NPN
R17  +Vcc Net-_Q28-Pad1_ 6.5K
Q28  Net-_Q28-Pad1_ Net-_Q28-Pad1_ Net-_Q25-Pad3_ eSim_PNP
Q27  ? Net-_Q25-Pad3_ Net-_Q27-Pad3_ eSim_NPN
Q30  Net-_Q28-Pad1_ Net-_Q27-Pad3_ Net-_Q30-Pad3_ eSim_NPN
Q31  ? Net-_Q28-Pad1_ Net-_Q31-Pad3_ eSim_NPN
Q32  Net-_Q32-Pad1_ Net-_Q32-Pad1_ Net-_Q28-Pad1_ eSim_PNP
R19  +Vcc Net-_Q32-Pad1_ 4.7k
Q33  Net-_Q32-Pad1_ Net-_Q31-Pad3_ Net-_Q30-Pad3_ eSim_NPN
R18  Net-_Q31-Pad3_ Net-_Q30-Pad3_ 8.4K
Q35  +Vcc Net-_Q32-Pad1_ Vco_output eSim_NPN
R20  Net-_Q30-Pad3_ -Vcc 2.6K
R22  Vco_output -Vcc 4.8K
Q24  Net-_Q24-Pad1_ Net-_Q24-Pad2_ -Vcc eSim_NPN
Q26  Net-_Q24-Pad1_ Net-_Q24-Pad1_ Net-_Q26-Pad3_ eSim_PNP
R16  Net-_Q24-Pad2_ -Vcc 7K
Q29  Net-_Q26-Pad3_ Net-_Q26-Pad3_ Net-_Q24-Pad2_ eSim_NPN
Q34  Net-_Q25-Pad3_ Net-_Q11-Pad1_ Net-_Q34-Pad3_ eSim_NPN
R21  Net-_Q34-Pad3_ -Vcc 2.4K
Q36  -Vcc Vco_output Net-_Q36-Pad3_ eSim_PNP
Q38  Net-_Q37-Pad2_ Net-_Q38-Pad2_ Net-_Q36-Pad3_ eSim_PNP
R23  +Vcc Net-_Q36-Pad3_ 16K
R24  Net-_Q37-Pad2_ Net-_Q26-Pad3_ 5.8k
Q37  Net-_Q36-Pad3_ Net-_Q37-Pad2_ Net-_Q26-Pad3_ eSim_NPN
Q40  Net-_Q38-Pad2_ Net-_Q11-Pad1_ Net-_Q40-Pad3_ eSim_NPN
R26  Net-_Q40-Pad3_ -Vcc 200
R25  +Vcc Net-_Q38-Pad2_ 4.3k
Q39  ? Net-_Q38-Pad2_ +Vcc eSim_NPN
U1  -Vcc Input Input Vco_output +Vcc Reference_output Vco_control_voltage Timming_resistor Timing_capacitor +Vcc PORT
Q15  ? Net-_Q15-Pad2_ Vco_control_voltage eSim_NPN
Q41  Net-_Q18-Pad2_ Net-_Q15-Pad2_ Timming_resistor eSim_PNP

.end
