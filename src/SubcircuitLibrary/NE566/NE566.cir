* C:\esim_1\eSim\src\SubcircuitLibrary\NE566\NE566.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 03/31/19 13:55:47

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
Q1  Net-_Q1-Pad1_ Net-_D10-Pad2_ Net-_D10-Pad1_ eSim_NPN
Q2  Net-_D10-Pad1_ Net-_Q2-Pad2_ Net-_D1-Pad1_ eSim_NPN
Q5  Net-_Q2-Pad2_ Net-_Q2-Pad2_ Net-_D1-Pad1_ eSim_NPN
D1  Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
D3  Net-_D1-Pad1_ Net-_D3-Pad2_ eSim_Diode
Q6  Net-_D3-Pad2_ Net-_D1-Pad2_ Net-_Q3-Pad2_ eSim_NPN
Q8  Net-_D9-Pad2_ Net-_D3-Pad2_ Net-_D5-Pad1_ eSim_NPN
Q7  Net-_Q3-Pad2_ Net-_Q3-Pad2_ Net-_Q7-Pad3_ eSim_NPN
Q3  Net-_D1-Pad2_ Net-_Q3-Pad2_ Net-_Q3-Pad3_ eSim_NPN
R1  Net-_Q3-Pad3_ Net-_D4-Pad2_ 5k
R3  Net-_Q7-Pad3_ Net-_D4-Pad2_ 5k
D4  Net-_D2-Pad1_ Net-_D4-Pad2_ eSim_Diode
Q4  Net-_D4-Pad2_ Net-_D2-Pad2_ Net-_Q15-Pad1_ eSim_NPN
D2  Net-_D2-Pad1_ Net-_D2-Pad2_ eSim_Diode
R2  Net-_D2-Pad2_ Net-_Q15-Pad1_ 5k
R4  Net-_Q9-Pad3_ Net-_Q15-Pad1_ 5k
Q10  Net-_D9-Pad2_ Net-_D5-Pad1_ Net-_Q10-Pad3_ eSim_NPN
Q9  Net-_D5-Pad1_ Net-_Q11-Pad2_ Net-_Q9-Pad3_ eSim_NPN
Q11  Net-_Q10-Pad3_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_NPN
D5  Net-_D5-Pad1_ Net-_D5-Pad2_ eSim_Diode
D6  Net-_D5-Pad1_ Net-_D6-Pad2_ eSim_Diode
Q12  Net-_D5-Pad2_ Net-_D6-Pad2_ Net-_Q12-Pad3_ eSim_NPN
D8  Net-_D5-Pad2_ Net-_D8-Pad2_ eSim_Diode
D7  Net-_D5-Pad2_ Net-_D7-Pad2_ eSim_Diode
R6  Net-_D9-Pad2_ Net-_D5-Pad2_ 5k
R8  Net-_D9-Pad2_ Net-_D8-Pad2_ 5k
Q14  Net-_D9-Pad2_ Net-_D8-Pad2_ Net-_Q14-Pad3_ eSim_NPN
Q13  Net-_D8-Pad2_ Net-_D7-Pad2_ Net-_Q12-Pad3_ eSim_NPN
R7  Net-_D7-Pad2_ Net-_Q12-Pad3_ 5k
Q15  Net-_Q15-Pad1_ Net-_Q14-Pad3_ Net-_Q15-Pad3_ eSim_PNP
Q16  Net-_Q15-Pad3_ Net-_Q16-Pad2_ Net-_D2-Pad1_ eSim_PNP
Q17  Net-_Q16-Pad2_ Net-_D9-Pad1_ Net-_Q15-Pad3_ eSim_PNP
R13  Net-_D9-Pad2_ Net-_D9-Pad1_ 5k
D9  Net-_D9-Pad1_ Net-_D9-Pad2_ eSim_Diode
R15  Net-_D9-Pad2_ Net-_Q11-Pad2_ 5k
R12  Net-_Q16-Pad2_ Net-_D2-Pad1_ 5k
R5  Net-_Q11-Pad3_ Net-_Q15-Pad1_ 5k
R9  Net-_Q12-Pad3_ Net-_Q15-Pad1_ 5k
R10  Net-_Q14-Pad3_ Net-_Q15-Pad1_ 5k
Q18  Net-_D9-Pad1_ Net-_Q11-Pad2_ Net-_Q18-Pad3_ eSim_NPN
Q19  Net-_Q11-Pad2_ Net-_Q11-Pad2_ Net-_Q19-Pad3_ eSim_NPN
R14  Net-_Q18-Pad3_ Net-_Q15-Pad1_ 5k
R16  Net-_Q19-Pad3_ Net-_Q15-Pad1_ 5k
U1  Net-_Q15-Pad1_ Net-_Q14-Pad3_ Net-_Q10-Pad3_ Net-_D10-Pad2_ Net-_Q1-Pad1_ Net-_D3-Pad2_ Net-_D9-Pad2_ PORT
R11  Net-_D9-Pad2_ Net-_Q15-Pad3_ 5k
D10  Net-_D10-Pad1_ Net-_D10-Pad2_ eSim_Diode
Q20  Net-_Q2-Pad2_ Net-_D10-Pad1_ Net-_Q1-Pad1_ eSim_PNP

.end
