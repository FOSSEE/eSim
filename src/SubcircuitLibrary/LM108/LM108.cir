* C:\esim_1\eSim\src\SubcircuitLibrary\LM108\LM108.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 03/31/19 16:57:39

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
R2  v+ Net-_Q2-Pad3_ 20k
Q2  Net-_Q2-Pad1_ Net-_Q2-Pad1_ Net-_Q2-Pad3_ eSim_PNP
Q5  Net-_Q13-Pad1_ Net-_Q2-Pad1_ Net-_Q11-Pad3_ eSim_PNP
Q3  Net-_Q2-Pad1_ Net-_Q14-Pad1_ Net-_Q1-Pad1_ eSim_NPN
Q7  CompensationA Net-_Q14-Pad1_ Net-_Q7-Pad3_ eSim_NPN
Q9  CompensationA CompensationA Net-_Q9-Pad3_ eSim_PNP
Q11  Net-_Q11-Pad1_ CompensationA Net-_Q11-Pad3_ eSim_PNP
R3  v+ Net-_Q9-Pad3_ 20K
R7  v+ Net-_Q11-Pad3_ 10K
Q1  Net-_Q1-Pad1_ Input- Net-_Q1-Pad3_ eSim_NPN
Q4  Net-_Q4-Pad1_ Input+ Input- eSim_NPN
Q6  Net-_Q4-Pad1_ Input- Input+ eSim_NPN
R1  Net-_Q1-Pad3_ Net-_Q10-Pad1_ 2K
R5  Net-_Q4-Pad1_ Net-_Q12-Pad3_ 50K
Q8  Net-_Q7-Pad3_ Input+ Net-_Q8-Pad3_ eSim_NPN
R8  v+ Net-_Q15-Pad3_ 10K
Q15  Net-_Q14-Pad1_ Net-_J1-Pad3_ Net-_Q15-Pad3_ eSim_PNP
R12  CompensationB Net-_Q11-Pad1_ 5.6k
Q13  Net-_Q13-Pad1_ Net-_Q13-Pad1_ Net-_Q13-Pad3_ eSim_NPN
Q17  Net-_Q11-Pad1_ Net-_Q13-Pad1_ Net-_Q13-Pad3_ eSim_NPN
Q14  Net-_Q14-Pad1_ Net-_Q14-Pad1_ Net-_Q12-Pad3_ eSim_NPN
R4  Net-_Q8-Pad3_ Net-_Q10-Pad1_ 2k
Q12  V- Net-_Q10-Pad1_ Net-_Q12-Pad3_ eSim_PNP
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_NPN
Q18  Net-_J1-Pad3_ Net-_J1-Pad1_ Net-_Q18-Pad3_ eSim_NPN
J1  Net-_J1-Pad1_ V- Net-_J1-Pad3_ eSim_NJF
R13  Net-_J1-Pad1_ Net-_Q16-Pad2_ 940
R14  Net-_Q18-Pad3_ Net-_Q24-Pad2_ 20k
Q24  Net-_Q13-Pad3_ Net-_Q24-Pad2_ Net-_Q24-Pad3_ eSim_NPN
R6  Net-_Q10-Pad3_ Net-_R10-Pad1_ 6.4K
R9  Net-_Q10-Pad2_ Net-_R10-Pad1_ 60K
R11  Net-_Q18-Pad3_ Net-_Q19-Pad3_ 20K
R10  Net-_R10-Pad1_ Net-_Q19-Pad3_ 500
R15  Net-_Q19-Pad3_ V- 1K
Q19  Net-_Q16-Pad2_ Net-_Q18-Pad3_ Net-_Q19-Pad3_ eSim_NPN
R17  Net-_Q24-Pad3_ V- 820
Q21  v+ Net-_J1-Pad3_ Net-_Q20-Pad1_ eSim_NPN
Q20  Net-_Q20-Pad1_ Net-_Q11-Pad1_ Net-_Q13-Pad3_ eSim_NPN
R16  Net-_J1-Pad3_ Net-_Q23-Pad1_ 2K
Q23  Net-_Q23-Pad1_ Net-_J1-Pad3_ Net-_Q22-Pad3_ eSim_NPN
Q26  v+ Net-_Q23-Pad1_ Net-_Q25-Pad2_ eSim_NPN
Q25  Net-_Q23-Pad1_ Net-_Q25-Pad2_ Output eSim_NPN
Q22  V- Net-_Q13-Pad3_ Net-_Q22-Pad3_ eSim_PNP
Q27  V- Net-_Q13-Pad3_ Net-_Q27-Pad3_ eSim_PNP
R18  Net-_Q25-Pad2_ Net-_Q27-Pad3_ 240
R19  Net-_Q25-Pad2_ Output 90
U1  CompensationA Input+ Input- V- Output v+ CompensationB PORT
Q29  Net-_J1-Pad3_ Net-_J1-Pad3_ v+ eSim_PNP
Q16  Net-_J1-Pad3_ Net-_Q16-Pad2_ Net-_Q10-Pad2_ eSim_NPN

.end
