* C:\Users\malli\eSim\src\SubcircuitLibrary\4_bit_FA\4_bit_FA.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 03/28/19 23:04:20

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U2  Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U16-Pad2_ d_or
U3  Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U24-Pad2_ d_and
U4  Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U17-Pad2_ d_or
U5  Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U26-Pad2_ d_and
U6  Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U18-Pad2_ d_or
U7  Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U10-Pad2_ d_and
U8  Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U10-Pad1_ d_or
U9  Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U31-Pad2_ d_and
U16  Net-_U1-Pad1_ Net-_U16-Pad2_ Net-_U16-Pad3_ d_and
U24  Net-_U16-Pad3_ Net-_U24-Pad2_ Net-_U17-Pad1_ d_or
U33  Net-_U23-Pad2_ Net-_U24-Pad2_ Net-_U33-Pad3_ d_or
U23  Net-_U16-Pad2_ Net-_U23-Pad2_ d_inverter
U38  Net-_U1-Pad1_ Net-_U33-Pad3_ Net-_U38-Pad3_ d_xor
U42  Net-_U38-Pad3_ Net-_U1-Pad13_ d_inverter
U17  Net-_U17-Pad1_ Net-_U17-Pad2_ Net-_U17-Pad3_ d_and
U26  Net-_U17-Pad3_ Net-_U26-Pad2_ Net-_U18-Pad1_ d_or
U34  Net-_U25-Pad2_ Net-_U26-Pad2_ Net-_U34-Pad3_ d_or
U25  Net-_U17-Pad2_ Net-_U25-Pad2_ d_inverter
U39  Net-_U17-Pad1_ Net-_U34-Pad3_ Net-_U39-Pad3_ d_xor
U44  Net-_U39-Pad3_ Net-_U1-Pad10_ d_inverter
U18  Net-_U18-Pad1_ Net-_U18-Pad2_ Net-_U18-Pad3_ d_and
U28  Net-_U18-Pad3_ Net-_U10-Pad2_ Net-_U28-Pad3_ d_or
U35  Net-_U27-Pad2_ Net-_U10-Pad2_ Net-_U35-Pad3_ d_or
U27  Net-_U18-Pad2_ Net-_U27-Pad2_ d_inverter
U40  Net-_U18-Pad1_ Net-_U35-Pad3_ Net-_U40-Pad3_ d_xor
U45  Net-_U40-Pad3_ Net-_U1-Pad11_ d_inverter
U31  Net-_U21-Pad2_ Net-_U31-Pad2_ Net-_U31-Pad3_ d_or
U21  Net-_U10-Pad1_ Net-_U21-Pad2_ d_inverter
U37  Net-_U28-Pad3_ Net-_U31-Pad3_ Net-_U37-Pad3_ d_xor
U43  Net-_U37-Pad3_ Net-_U1-Pad12_ d_inverter
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ Net-_U10-Pad3_ d_and
U32  Net-_U1-Pad1_ Net-_U32-Pad2_ Net-_U32-Pad3_ d_and
U41  Net-_U32-Pad3_ Net-_U41-Pad2_ Net-_U1-Pad14_ d_or
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ PORT
X1  Net-_U10-Pad1_ Net-_U18-Pad2_ Net-_U17-Pad2_ Net-_U16-Pad2_ Net-_U32-Pad2_ 4_and
X4  Net-_U10-Pad1_ Net-_U18-Pad2_ Net-_U26-Pad2_ Net-_X3-Pad3_ 3_and
X2  Net-_U10-Pad1_ Net-_U18-Pad2_ Net-_U17-Pad2_ Net-_U24-Pad2_ Net-_X2-Pad5_ 4_and
X3  Net-_U31-Pad2_ Net-_U10-Pad3_ Net-_X3-Pad3_ Net-_X2-Pad5_ Net-_U41-Pad2_ 4_OR

.end
